# EAGLE board SOL_AMPV3_1_7 (EAGLE 7.6.0), part 4 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND  (via drill 0.4, 0.5, 0.6) (continued)
  pour Top (rank 2): 107.44,109.22 111,109.22 111,107.19 107.44,107.19
GPIO2
  Top 0.305: GPIO2.TP X3.C26
  BOTTOM 0.305: R56.2 136.91,192.91 GPIO2.TP
HVCON
  Top 0.305: 128.63,9.37 X6.1
  Top 0.406: F1.2 128.63,9.37
HVFUSE
  Top 0.406: F1.1 134.14,9.19 R8.2
HVIN
  Top 0.254: U3.4 114.55,11.04 114.55,11.43 114.42,11.56 U3.5 114.03,12.18 114.55,12.7 | 114.55,12.7 114.55,14.29 R17.1 114.55,14.92 114.55,16.51 111.38,16.51 111.06,16.19 R9.2 | 116.09,12.97 115.82,12.7 114.55,12.7
  Top 0.305: HVIN.TP 121.54,12.19 120.14,13.59 118.36,13.59 117.86,13.08 117.13,13.08 C37.1 116.24,13.12 116.09,12.97
  Top 0.406: HVIN.TP 121.61,12.06 OK1.4
  BOTTOM 0.406: R60.1 123.82,14.35 HVIN.TP
HVSW  (via drill 0.6)
  Top 0.406: R8.1 133.5,12.04 132.2,13.54 | 132.2,13.54 v131.95,13.82 | v131.95,13.82 131.83,13.97 128.78,13.97 128.27,14.22 OK1.5 | v131.95,13.82 131.95,13.79 132.2,13.54
  BOTTOM 0.406: R60.2 128.02,14.73 128.78,13.97 131.81,13.97 v131.95,13.82
I2CEN  (via drill 0.6)
  Top 0.254: X3.A26 143.13,194.31 140.97,194.31 140.46,194.82 140.46,196.09 139.95,196.6 139.45,196.85 134.87,196.85 133.6,195.58 R46.1 131.06,195.56 131.06,194.31 127.89,194.31 v127.25,194.94 | U5.6 119.89,204.72 120.27,205.1 v123.44,205.1 | U13.6 122.81,84.45 124.08,85.09 125.35,85.09
  Top 0.305: v127.25,136.53 v136.14,136.53 | v133.6,86.36 132.97,85.09 125.35,85.09
  Route3 0.254: v127.25,194.94 123.44,196.22 v123.44,205.1
  Route3 0.305: v127.25,194.94 v127.25,136.53 | v136.14,136.53 137.41,132.08 137.41,115.57 134.87,107.95 134.87,94.61 133.6,92.08 v133.6,86.36
IN0
  Top 0.406: D0:C41.2 28.96,205.61 28.32,204.98 27.15,204.98 D0:R47.2 26.95,204.98 26.42,204.98 25.91,205.49 25.91,205.74 25.65,205.99 24.64,205.99 23.24,206.88 6.73,206.88 X1.A32
IN1
  Top 0.305: D1:R47.2 72.75,203.58 71.12,203.58 70.74,203.2 10.41,203.2 9.4,202.18 6.35,202.18 X1.A30
  Top 0.406: D1:C41.2 75.95,203.33 75.31,202.69 74.14,202.69 D1:R47.2
IN2
  Top 0.305: D2:R47.2 26.65,194.06 26.16,194.06 25.91,194.31 25.02,194.31 21.34,196.98 6.22,196.98 X1.A28
  Top 0.406: D2:C41.2 28.96,194.18 28.32,193.55 27.15,193.55 D2:R47.2
IN3
  Top 0.305: D3:R47.2 73.56,190.86 72.64,191.77 70.74,191.77 70.1,192.41 70.1,193.68 69.47,194.31 59.31,194.31 56.13,191.13 23.11,191.13 21.84,192.41 21.84,193.68 21.21,194.31 10.41,194.31 9.91,193.8 9.91,192.91 8.89,191.9 6.48,191.9 X1.A26
  Top 0.406: D3:C41.2 75.95,191.39 75.31,190.75 74.14,190.75 D3:R47.2
IN4
  Top 0.305: D4:R47.2 26.39,178.44 24.38,178.44 23.75,179.71 23.11,184.15 11.94,184.15 9.4,186.69 6.6,186.69 X1.A24
  Top 0.406: D4:C41.2 28.96,178.94 28.32,178.31 27.15,178.31 D4:R47.2
IN5
  Top 0.305: D5:R47.2 73.38,176.53 69.47,176.53 68.2,175.26 17.4,175.26 11.56,181.61 6.6,181.61 X1.A22
  Top 0.406: D5:C41.2 75.95,176.4 75.31,175.77 74.14,175.77 D5:R47.2
IN6
  Top 0.305: D6:R47.2 27.03,165.74 25.65,165.74 23.11,168.28 23.11,171.45 21.84,172.72 14.86,172.72 11.05,176.53 6.6,176.53 X1.A20
  Top 0.406: D6:C41.2 28.96,166.24 28.32,165.61 27.15,165.61 D6:R47.2
IN7
  Top 0.305: D7:R47.2 73.94,164.44 73.28,165.1 73.15,165.1 72.9,165.35 70.36,165.35 68.2,163.19 18.03,163.19 10.92,171.45 6.6,171.45 X1.A18
  Top 0.406: D7:C41.2 75.95,164.97 75.31,164.34 74.14,164.34 D7:R47.2
IN8
  Top 0.305: 27.56,152.91 27.3,153.16 26.16,153.16 25.65,153.67 23.11,153.67 11.18,166.37 6.6,166.37 X1.A16
  Top 0.406: D8:C41.2 28.96,153.54 28.32,152.91 27.56,152.91 27.15,152.91 D8:R47.2
IN9
  Top 0.305: D9:R47.2 73.89,151.89 73.41,151.89 70.99,153.03 70.74,153.67 69.09,156.84 58.42,156.84 56.01,150.5 21.21,150.5 14.86,155.57 14.86,158.75 12.57,161.29 6.6,161.29 X1.A14
  Top 0.406: D9:C41.2 75.95,152.27 75.31,151.64 74.14,151.64 D9:R47.2
IN10
  Top 0.305: D10:R47.2 29.44,139.83 28.96,139.83 28.45,140.34 26.92,140.34 26.29,140.97 26.29,146.05 25.65,146.69 15.49,146.69 10.41,148.59 10.41,154.94 9.02,156.21 6.6,156.21 X1.A12
  Top 0.406: D10:C41.2 31.5,140.21 30.86,139.57 29.69,139.57 D10:R47.2
IN11  (via drill 0.6)
  Top 0.305: v12.45,150.5 14.86,148.59 66.29,148.59 70.74,144.78 70.74,140.34 71.12,139.95 71.25,139.95 71.5,139.7 73.15,139.7 73.81,139.04 D11:R47.2
  Top 0.406: D11:C41.2 75.95,139.57 75.31,138.94 74.14,138.94 D11:R47.2
  Route2 0.305: v12.45,150.5 12.32,150.5 11.68,151.13 6.6,151.13 X1.A10
IN12
  Top 0.305: D12:C41.2 75.52,128.88 D12:R47.2 74.02,128.91 72.01,128.91 70.1,130.81 70.1,135.25 69.47,135.89 57.4,135.89 56.13,137.16 25.65,137.16 24.38,138.43 24.38,142.88 22.61,145.16 11.81,145.16 10.92,146.05 6.6,146.05 X1.A8
IN13
  Top 0.305: D13:C41.2 28.7,128.14 28.19,127.64 27.08,127.64 | 27.08,127.64 D13:R47.2 | 27.08,127.64 25.02,127.64 22.48,130.18 22.48,133.35 21.84,133.99 14.99,133.99 9.78,139.19 9.78,140.72 9.53,140.97 6.6,140.97 X1.A6
IN14
  Top 0.305: D14:C41.2 75.52,113.64 D14:R47.2 74.02,113.67 72.01,113.67 68.83,116.84 65.02,124.46 22.48,124.46 17.4,129.54 15.37,129.54 10.03,135.13 9.27,135.89 6.6,135.89 X1.A4
IN15
  Top 0.305: D15:C41.2 28.53,114.91 D15:R47.2 26.95,114.81 26.16,114.81 24.77,116.2 23.11,116.2 23.11,120.65 22.48,121.28 20.57,121.28 10.92,130.81 6.6,130.81 X1.A2
IN16
  Top 0.305: D16:R47.2 26.29,98.42 13.59,98.42 12.32,97.16 12.32,91.44 9.78,88.9 6.6,88.9 X2.A32
  Top 0.406: D16:C41.2 28.96,98.93 28.32,98.3 27.15,98.3 D16:R47.2
IN17
  Top 0.305: D17:R47.2 61.09,95.38 58.67,96.39 16.13,96.39 14.22,94.61 14.22,91.44 9.78,86.36 9.78,85.22 8.38,83.82 6.6,83.82 X2.A30
  Top 0.406: D17:C41.2 65.15,96.01 64.52,95.38 63.35,95.38 D17:R47.2
IN18
  Top 0.305: D18:R47.2 26.29,87.63 14.22,87.63 11.68,85.09 11.05,83.19 9.53,80.14 9.53,79.38 8.89,78.74 6.6,78.74 X2.A28
  Top 0.406: D18:C41.2 28.96,87.76 28.32,87.12 27.15,87.12 D18:R47.2
IN19
  Top 0.305: D19:R47.2 62.84,84.45 14.22,84.45 9.65,75.69 9.65,74.42 8.89,73.66 6.6,73.66 X2.A26
  Top 0.406: D19:C41.2 65.15,84.58 64.52,83.95 63.35,83.95 D19:R47.2
IN20
  Top 0.305: D20:R47.2 27.56,71.75 26.92,72.39 12.95,72.39 10.29,69.85 8.89,68.45 6.73,68.45 X2.A24
  Top 0.406: D20:C41.2 30.23,72.26 29.59,71.63 28.42,71.63 D20:R47.2
IN21
  Top 0.305: D21:R47.2 70.23,68.71 69.47,67.94 66.93,67.94 65.66,69.22 14.86,69.22 9.14,63.5 6.6,63.5 X2.A22
  Top 0.406: D21:C41.2 72.14,69.72 71.5,69.09 70.33,69.09 D21:R47.2
IN22
  Top 0.305: D22:R47.2 25.65,60.96 11.68,60.96 10.29,59.69 9.02,58.42 6.6,58.42 X2.A20
  Top 0.406: D22:C41.2 28.96,60.83 28.32,60.2 27.15,60.2 D22:R47.2
IN23
  Top 0.305: 74.55,57.66 74.42,57.78 13.59,57.78 10.79,54.61 9.4,53.21 6.73,53.21 X2.A18
  Top 0.406: D23:C41.2 75.95,58.29 75.31,57.66 74.55,57.66 74.14,57.66 D23:R47.2
IN24
  Top 0.305: 27.56,44.96 26.29,45.72 23.75,45.72 22.48,48.26 6.6,48.26 X2.A16
  Top 0.406: D24:C41.2 28.96,45.59 28.32,44.96 27.56,44.96 27.15,44.96 D24:R47.2
IN25
  Top 0.305: D25:R47.2 73.89,43.18 73.28,43.18 72.64,43.81 72.01,43.81 69.47,46.35 65.02,46.35 61.85,43.18 6.6,43.18 X2.A14
  Top 0.406: D25:C41.2 75.95,43.56 75.31,42.93 74.14,42.93 D25:R47.2
IN26
  Top 0.305: D26:R47.2 25.65,34.29 24.38,34.29 23.75,34.92 23.75,36.96 22.48,38.1 6.6,38.1 X2.A12
  Top 0.406: D26:C41.2 28.96,34.16 28.32,33.53 27.15,33.53 D26:R47.2
IN27
  Top 0.305: D27:R47.2 72.16,31.6 70.74,33.02 54.86,33.02 52.32,30.48 23.75,30.48 21.21,33.02 20.7,33.78 20.07,34.42 10.29,34.42 8.89,33.02 6.6,33.02 X2.A10
  Top 0.406: D27:C41.2 75.95,32.13 75.31,31.5 74.14,31.5 D27:R47.2
IN28
  Top 0.305: D28:R47.2 26.39,20.95 25.02,20.95 23.11,23.5 11.94,23.5 9.78,25.78 9.78,27.56 9.4,27.94 6.6,27.94 X2.A8
  Top 0.406: D28:C41.2 29.59,20.83 28.96,20.19 27.79,20.19 D28:R47.2
IN29
  Top 0.305: D29:R47.2 73.81,17.14 69.47,17.14 68.2,17.78 14.86,17.78 9.53,22.86 6.6,22.86 X2.A6
  Top 0.406: D29:C41.2 75.95,17.91 75.31,17.27 74.14,17.27 D29:R47.2
IN30
  Top 0.305: D30:R47.2 27.53,9.02 27.05,9.02 26.67,9.4 26.67,9.53 26.29,9.53 25.65,10.16 25.02,10.16 23.11,13.34 16.13,13.34 9.78,17.78 6.6,17.78 X2.A4
  Top 0.406: D30:C41.2 29.59,9.4 28.96,8.76 27.79,8.76 D30:R47.2
IN31
  Top 0.305: D31:R47.2 74.02,5.71 73.28,5.71 72.01,6.35 71.37,6.35 70.74,7.62 60.58,7.62 59.31,6.35 19.3,6.35 12.45,12.7 6.6,12.7 X2.A2
  Top 0.406: D31:C41.2 75.95,6.22 75.31,5.59 74.14,5.59 D31:R47.2
IP0
  Top 0.254: D0:C31.2 27.27,212.28 D0:R37.1
  Top 0.305: 22.35,208.28 X1.B32
  Top 0.406: 22.35,208.28 24.13,212.09 26.65,212.09 D0:R37.1
IP1
  Top 0.254: D1:C31.2 74.26,209.99 D1:R37.1
  Top 0.305: D1:R37.1 71.4,210.21 68.83,207.65 68.83,205.1 67.56,203.84 8.51,203.84 X1.B30
IP2
  Top 0.254: D2:C31.2 27.27,200.85 D2:R37.1
  Top 0.305: D2:R37.1 26.65,200.66 25.15,200.66 23.11,198.63 8.64,198.63 7.87,198.37 X1.B28
IP3
  Top 0.254: D3:C31.2 74.55,198.06 74.26,198.06 D3:R37.1
  Top 0.305: 74.48,198.12 74.55,198.06 | D3:R37.1 73.89,198.12 72.01,198.12 69.47,195.58 69.47,194.94 58.67,194.94 55.5,191.77 23.37,191.77 22.48,192.66 22.48,194.31 21.84,194.94 9.78,194.94 X1.B26
IP4
  Top 0.254: D4:C31.2 27.27,185.61 D4:R37.1
  Top 0.305: D4:R37.1 26.82,186.06 25.02,186.06 23.75,184.78 12.45,184.78 10.16,186.94 9.14,187.96 X1.B24
IP5
  Top 0.254: D5:C31.2 74.55,183.07 74.26,183.07 D5:R37.1
  Top 0.305: 74.55,183.07 74.1,183.51 70.1,183.51 68.83,182.25 68.83,177.16 67.56,175.9 18.03,175.9 11.56,182.88 X1.B22
IP6
  Top 0.254: D6:C31.2 27.27,172.91 D6:R37.1
  Top 0.305: D6:R37.1 26.82,173.35 15.49,173.35 11.05,177.8 X1.B20
IP7
  Top 0.254: D7:C31.2 74.26,171.64 D7:R37.1
  Top 0.305: D7:R37.1 73.64,171.45 70.74,171.45 70.1,170.81 70.1,167 66.93,163.83 18.67,163.83 11.05,172.72 X1.B18
IP8
  Top 0.254: D8:C31.2 27.27,160.21 D8:R37.1
  Top 0.305: D8:R37.1 26.65,160.02 24.38,160.02 22.48,158.12 19.94,158.12 11.3,167.64 X1.B16
IP9
  Top 0.254: D9:C31.2 74.26,158.94 D9:R37.1
  Top 0.305: D9:R37.1 73.81,159.38 72.01,159.38 70.74,157.48 57.78,157.48 55.37,151.13 21.84,151.13 15.49,156.21 15.49,159.38 12.45,162.56 X1.B14
IP10
  Top 0.254: D10:C31.2 29.81,146.88 D10:R37.1
  Top 0.305: D10:R37.1 29.36,147.32 15.49,147.32 11.05,149.22 11.05,154.94 9.65,157.48 X1.B12
IP11  (via drill 0.6)
  Top 0.254: D11:C31.2 74.26,146.24 D11:R37.1
  Top 0.305: v12.45,152.4 15.49,149.22 66.93,149.22 70.74,146.69 D11:R37.1
  Route2 0.305: X1.B10 v12.45,152.4
IP12
  Top 0.305: D12:C31.2 75.83,136.3 D12:R37.1 73.81,136.53 58.04,136.53 56.77,137.79 26.29,137.79 25.02,139.06 25.02,143.51 23.24,145.8 12.45,145.8 10.92,147.32 X1.B8
IP13
  Top 0.305: D13:C31.2 28.84,135.03 D13:R37.1 26.9,134.87 26.16,134.87 25.91,134.62 15.49,134.62 10.92,139.19 10.92,141.22 9.65,142.24 X1.B6
IP14
  Top 0.305: D14:C31.2 75.83,121.06 D14:R37.1 73.94,121.16 69.09,121.16 65.15,125.09 23.11,125.09 18.03,130.18 16,130.18 10.54,136.14 9.4,137.16 X1.B4
IP15
  Top 0.305: D15:C31.2 28.84,122.33 D15:R37.1 26.82,122.56 20.57,122.56 10.92,132.08 X1.B2
IP16
  Top 0.254: D16:C31.2 27.27,105.6 D16:R37.1
  Top 0.305: 26.92,105.41 D16:R37.1 23.75,105.79 23.11,104.78 23.11,100.33 21.84,99.06 12.95,99.06 11.68,97.79 11.68,92.08 11.3,91.69 9.4,91.69 X2.B32
IP17
  Top 0.254: D17:C31.2 63.46,102.68 D17:R37.1
  Top 0.305: D17:R37.1 60.58,102.87 58.67,101.6 58.67,97.79 58.04,97.03 14.86,97.03 13.59,95.89 13.59,91.44 7.87,85.72 X2.B30
IP18
  Top 0.254: D18:C31.2 27.27,94.42 D18:R37.1
  Top 0.305: D18:R37.1 23.11,94.61 22.48,93.34 22.48,88.9 21.84,88.27 13.59,88.27 11.05,85.72 10.41,83.82 9.14,81.28 X2.B28
IP19
  Top 0.254: D19:C31.2 63.75,91.25 63.46,91.25 D19:R37.1
  Top 0.305: 63.56,91.44 63.75,91.25 | D19:R37.1 63.22,91.44 61.21,91.44 58.67,88.9 57.66,85.09 13.59,85.09 8.89,76.45 7.87,75.44 X2.B26
IP20
  Top 0.254: D20:C31.2 28.54,78.93 D20:R37.1
  Top 0.305: D20:R37.1 26.29,78.74 25.15,77.09 25.15,73.91 22.48,73.03 11.3,73.03 9.78,71.63 9.14,71.12 X2.B24
IP21
  Top 0.254: D21:C31.2 70.45,76.39 D21:R37.1
  Top 0.305: D21:R37.1 69.83,76.2 67.56,76.2 66.93,75.56 66.93,71.75 65.02,69.85 14.22,69.85 10.29,66.04 9.02,64.77 X2.B22
IP22
  Top 0.254: D22:C31.2 27.27,67.5 D22:R37.1
  Top 0.305: D22:R37.1 25.02,67.31 23.75,66.67 23.75,62.23 23.11,61.59 11.05,61.59 10.29,60.96 9.02,59.69 X2.B20
IP23
  Top 0.254: D23:C31.2 74.26,64.96 D23:R37.1
  Top 0.305: D23:R37.1 73.64,64.77 71.37,64.77 70.1,63.5 70.1,59.05 69.47,58.42 12.95,58.42 10.79,55.88 9.53,54.61 X2.B18
IP24
  Top 0.254: D24:C31.2 27.27,52.26 D24:R37.1
  Top 0.305: D24:R37.1 24.38,52.07 23.75,51.44 23.75,50.16 22.48,48.9 10.79,48.9 10.41,49.28 8.13,49.28 X2.B16
IP25
  Top 0.254: D25:C31.2 74.55,50.23 74.26,50.23 D25:R37.1
  Top 0.305: 74.55,50.23 74.48,50.16 71.37,50.16 70.74,49.53 70.74,48.26 69.47,46.99 64.39,46.99 61.21,43.81 10.79,43.81 9.91,44.45 X2.B14
IP26
  Top 0.254: D26:C31.2 27.27,40.83 D26:R37.1
  Top 0.305: D26:R37.1 22.99,39.37 X2.B12
IP27
  Top 0.254: D27:C31.2 74.26,38.8 D27:R37.1
  Top 0.305: D27:R37.1 71.02,39.01 70.1,38.1 70.1,34.29 69.47,33.66 54.23,33.66 51.69,31.11 24.38,31.11 | 22.86,33.15 21.84,34.92 21.21,35.56 9.14,35.56 X2.B10
  Top 0.406: 24.38,31.11 22.86,33.15
IP28
  Top 0.254: D28:C31.2 27.9,27.5 D28:R37.1
  Top 0.305: D28:R37.1 27.28,27.3 25.02,27.3 23.11,24.64 12.06,24.64 10.41,26.8 10.41,28.45 9.78,29.21 X2.B8
IP29
  Top 0.254: D29:C31.2 74.26,24.57 D29:R37.1
  Top 0.305: D29:R37.1 74.02,24.77 72.01,24.77 70.74,23.5 70.74,19.68 69.47,18.41 15.75,18.41 9.65,24.13 X2.B6
IP30
  Top 0.254: D30:C31.2 27.9,16.07 D30:R37.1
  Top 0.305: D30:R37.1 27.28,15.88 25.65,15.88 23.75,13.97 16.76,13.97 9.78,19.05 X2.B4
IP31
  Top 0.254: D31:C31.2 74.26,12.89 D31:R37.1
  Top 0.305: D31:R37.1 73.64,12.7 71.37,12.7 70.74,12.06 70.74,10.16 68.83,8.26 59.94,8.26 58.67,6.99 20.45,6.99 13.08,13.97 X2.B2
LDAC1  (via drill 0.5)
  Top 0.305: U1.4 15.13,189.36 R5.2 14.49,187.47 v14.48,187.45
  Route2 0.305: v14.48,175.77 15.49,174.75 55.12,174.75 v55.63,173.99
  Route3 0.305: v14.48,187.45 v14.48,175.77 | v55.63,173.99 55.63,167.89 T1.1
LDAC2  (via drill 0.5)
  Top 0.305: U2.4 60.58,188.09 v59.18,186.69 R11.2
  Route3 0.305: v59.18,186.69 R11.2 56.9,184.02 T1.2
LDAC3  (via drill 0.5)
  Top 0.305: U6.4 v14.73,137.92 13.97,138.68 12.95,138.68 12.45,139.19 12.45,140.19 R22.2
  Route2 0.305: v14.73,165.1 19.05,165.1 19.56,164.59 57.91,164.59 T1.3
  Route3 0.305: v14.73,137.92 v14.73,165.1
LDAC4  (via drill 0.5)
  Top 0.305: U7.4 v60.58,140.46 60.83,140.21 R25.2
  Route3 0.305: v60.58,140.46 60.58,142.37 58.67,144.78 58.67,165.1 58.17,166.12 58.17,168.4 T1.4
LDAC5  (via drill 0.5)
  Top 0.305: U9.4 v14.99,76.96 14.86,76.83 14.22,76.83 13.59,76.2 R29.2
  Route2 0.305: v14.99,54.36 v54.1,54.36
  Route3 0.305: v14.99,76.96 v14.99,54.36 | v54.1,54.36 54.1,46.99 T3.1
LDAC6  (via drill 0.5)
  Top 0.305: U10.4 58.17,74.42 v58.17,73.28 R36.2
  Route3 0.305: v58.17,73.28 58.17,68.58 55.12,67.06 T3.2
LDAC7  (via drill 0.5)
  Top 0.305: U11.4 14.61,28.07 14.48,27.94 v14.48,26.8 13.7,26.02 R41.2 | v54.23,44.7 56.39,44.7 T3.3
  Route2 0.305: v14.48,42.16 49.53,42.16 50.04,42.67 52.07,42.67 52.58,42.16 v54.23,42.16
  Route3 0.305: v14.48,26.8 v14.48,42.16 | v54.23,42.16 v54.23,44.7
LDAC8  (via drill 0.5)
  Top 0.305: U12.4 59.56,22.35 59.05,21.84 v59.05,20.45 R44.2
  Route3 0.305: v59.05,20.45 58.55,22.48 56.77,24.51 56.77,44.58 56.52,44.83 56.52,47.37 T3.4
N$1
  Top 0.305: U1.1 12.04,190.86 | 12.04,190.86 11.68,190.5 C1.1 | 12.04,190.86 12.04,192.14 R4.1
N$2
  Top 0.305: R38.2 R57.1 126.73,69.83 | 126.73,69.83 U17.3 | C29.1 126.6,69.45 126.73,69.83
N$3
  Top 0.406: LED1.C 109.25,113.9 R1.2
N$4  (via drill 0.6)
  Top 0.305: OK1.1 133.04,25.47 v133.1,25.53
  BOTTOM 0.305: v133.1,25.53 133.11,25.53 R39.1
N$5
  Top 0.305: U14.8 122.48,124.16 122.17,124.46 121.55,124.46 R53.2 R52.2
N$6
  Top 0.305: U2.1 60.3,189.59 59.63,188.91 | 59.63,188.91 59.31,188.59 C2.1 | R10.1 59.31,189.23 59.63,188.91
N$7
  Top 0.254: R15.1 T14.TP 110.49,9.91 U3.11
N$8
  Top 0.305: C9.1 14.21,140.21 14.99,140.21 15.65,139.55 15.65,139.42 U6.1 17.02,139.8 17.02,141.22 18.29,142.49 19.56,142.49 19.95,142.89 R21.1
N$9
  Top 0.254: U3.6 113.53,12.45 113.28,12.7 112.32,13.48 R17.2
N$10
  Top 0.254: U4.6 R13.1
N$11
  Top 0.305: U7.1 60.86,141.96 60.58,142.24 | 60.58,142.24 C10.1 | R24.1 60.56,142.25 60.58,142.24
N$12
  Top 0.305: R28.1 15.49,79.36 C11.1 15.88,78.36 15.98,78.46 U9.1
N$13  (via drill 0.6)
  Top 0.254: U3.1 115.05,9.41 115.19,9.27 v115.19,7.62 | R16.1 124.06,6.97 T15.TP
  Route2 0.254: v115.19,7.62 117.73,7.62 118.36,8.26 120.27,8.26 120.9,7.62 123.44,7.62 T15.TP
N$14
  Top 0.305: R35.1 56.9,76.2 | 56.9,76.2 56.9,76.09 C12.1 | U10.1 57.17,75.92 56.9,76.2
N$15
  Top 0.305: U11.1 13.96,29.57 C13.1 13.59,29.48 13.59,30.48 14.21,31.1 R40.1
N$16
  Top 0.305: U12.1 59.04,23.85 | 59.04,23.85 58.67,23.85 R43.1 | 59.04,23.85 C14.1
N$20
  Top 0.305: U21.2 R30.1 R31.2
N$21
  Top 1.016: X8.3 F3.1
N$22
  Top 0.305: U22.2 131.97,94.87 R2.1 132.46,95.11 R3.2
N$23
  Top 0.305: R58.2 124.19,193.68 R59.1 | R59.1 122.92,190.63 C26.1 | R59.1 122.17,192.41 121.54,193.04 120.07,193.04 U19.3
N$25
  Top 1.016: F2.2 X8.1
N$27
  Top 0.305: R50.2 127.25,102.36 T9.2
N$28
  BOTTOM 0.305: R55.1 127.9,190.39 T10.1
ON0
  Top 0.254: D0:R45.2 45.47,208.79 45.47,206.25 D0:R44.2 D0:C44.2 48.01,204.98 48.32,205.3 48.94,205.3 D0:R48.2 | D0:D41.3 51.05,205.28
  Top 0.305: D0:R48.2 51.05,205.28 52.63,205.28 54.74,205.87 54.74,210.82 56.01,212.09 103.76,212.09 108.84,207.01 108.84,187.96 109.47,187.32 134.87,187.32 136.78,189.23 143.13,189.23 143.76,188.59 143.76,188.34 X3.A24
ON1  (via drill 0.6)
  Top 0.254: D1:R45.2 92.46,206.5 92.46,203.96 D1:R44.2 D1:C44.2 95,202.69 95.31,203.01 95.93,203.01 D1:R48.2
  Top 0.305: D1:R48.2 96.73,202.49 99.83,202.52 | 99.83,202.52 v104.39,202.56 | v107.57,202.56 107.57,201.42 107.06,201.42 106.93,188.21 108.97,186.06 137.16,186.06 X3.C24 | D1:D41.3 99.82,202.53 99.83,202.52
  BOTTOM 0.305: v104.39,202.56 v107.57,202.56
ON2
  Top 0.254: D2:R45.2 45.47,197.36 45.47,194.82 D2:R44.2 D2:C44.2 48.01,193.55 48.32,193.87 48.94,193.87 D2:R48.2
  Top 0.305: X3.A21 142.88,181.61 142.88,183.77 142.49,184.15 137.41,184.15 136.14,182.37 107.57,182.37 104.01,187.45 104.01,198.5 103,200.03 58.04,200.03 57.66,199.64 57.66,196.6 55.63,195.58 54.41,193.34 53.09,193.33 | D2:R48.2 49.73,193.85 50.29,193.29 53.09,193.33 | D2:D41.3 53.09,193.34 53.09,193.33
ON3
  Top 0.254: D3:R45.2 92.46,194.56 92.46,192.02 D3:R44.2 D3:C44.2 95,190.75 95.31,191.07 D3:R48.2
  Top 0.305: X3.C21 105.03,180.34 101.35,183.9 101.35,190.5 100.33,190.5 | 100.33,190.5 97.28,190.5 96.77,191.01 D3:R48.2 | D3:D41.3 100.33,190.5
ON4
  Top 0.254: D4:R45.2 45.47,182.12 45.47,179.58 D4:R44.2 D4:C44.2 48.01,178.31 48.32,178.62 48.94,178.62 D4:R48.2
  Top 0.305: X3.A18 144.14,172.97 143,174.12 143,175.77 142.24,176.53 134.87,176.53 133.6,177.8 104.65,177.8 96.52,186.06 71.37,186.06 69.47,184.15 56.9,184.15 56.13,183.39 56.13,179.83 55.12,178.31 52.58,178.31 | D4:R48.2 50.09,178.61 50.8,178.31 52.58,178.31 | D4:D41.3 52.58,178.31
ON5
  Top 0.254: D5:R45.2 92.46,179.58 92.46,177.04 D5:R44.2 D5:C44.2 95,175.77 95.31,176.09 95.93,176.09 D5:R48.2 | D5:D41.3 98.81,175.67
  Top 0.305: X3.C18 134.87,172.72 131.7,175.9 104.9,175.9 103.76,175.26 99.95,175.26 99.47,175.74 99.47,175.67 98.81,175.67 96.75,175.67 96.47,176.07 D5:R48.2
ON6
  Top 0.254: D6:R45.2 45.47,169.42 45.47,166.88 D6:R44.2 D6:C44.2 48.01,165.61 48.32,165.93 48.94,165.93 D6:R48.2
  Top 0.305: X3.A15 142.49,166.37 137.41,166.37 136.14,165.74 106.93,165.74 106.17,166.88 106.17,171.96 105.41,172.72 96.77,172.72 96.27,173.23 60.45,173.23 58.67,171.45 56.01,171.45 55.37,170.81 55.37,166.88 54.61,165.61 52.58,165.61 | D6:R48.2 49.32,165.91 50.55,165.61 52.58,165.61 | D6:D41.3 52.58,166.32 52.58,165.61
ON7
  Top 0.254: D7:R45.2 92.46,168.15 92.46,165.61 D7:R44.2 D7:C44.2 95,164.34 95.31,164.66 95.93,164.66 D7:R48.2 | D7:D41.3 99.31,164.64
  Top 0.305: D7:R48.2 98.93,164.64 | 98.93,164.64 99.31,164.64 100.15,164.64 100.97,163.83 136.14,163.83 138.68,161.29 139.95,161.29 140.33,161.93 140.33,163.58 X3.C15 | 98.96,164.67 98.93,164.64
ON8
  Top 0.254: D8:R45.2 45.47,156.72 45.47,154.18 D8:R44.2 D8:C44.2 48.01,152.91 48.32,153.23 48.94,153.23 D8:R48.2
  Top 0.305: X3.A12 143.13,158.75 136.78,158.75 132.97,161.29 58.04,161.29 56.64,157.99 54.61,153.29 52.2,153.26 | D8:R48.2 52.2,153.26 | D8:D41.3 52.2,154.12 52.2,153.26
ON9
  Top 0.254: D9:R45.2 92.46,155.45 92.46,152.91 D9:R44.2 D9:C44.2 95,151.64 95.31,151.96 95.93,151.96 D9:R48.2 | D9:D41.3 99.31,151.51
  Top 0.305: D9:R48.2 95.95,151.83 96.27,151.51 99.31,151.51 101.98,151.51 104.01,154.31 137.41,154.31 138.05,153.67 139.95,153.67 140.46,154.18 140.46,156.21 X3.C12
ON10  (via drill 0.6)
  Top 0.254: D10:R45.2 48.01,143.38 48.01,140.84 D10:R44.2 D10:C44.2 50.55,139.57 50.86,139.89 D10:R48.2 | v53.34,139.83 53.9,139.83 D10:D41.3
  Top 0.305: D10:R48.2 52.5,139.88 v53.34,139.83 | v72.64,149.86 112.01,149.86 113.28,151.13 143.13,151.13 143.76,150.5 143.76,150.24 X3.A9
  Route2 0.305: v53.34,147.32 68.83,147.32 v72.64,149.86
  Route3 0.305: v53.34,139.83 v53.34,147.32
ON11
  Top 0.254: D11:R45.2 92.46,142.75 92.46,140.21 D11:R44.2 D11:C44.2 95,138.94 95.31,139.26 95.93,139.26 D11:R48.2 | D11:D41.3 99.34,139.27
  Top 0.305: D11:R48.2 99.31,139.24 | 99.31,139.24 103.68,139.24 104.65,140.72 104.65,143.13 105.28,144.78 134.87,144.78 136.14,146.05 139.95,146.05 140.46,146.56 140.46,148.46 X3.C9 | 99.34,139.27 99.31,139.24
ON12
  Top 0.254: 92.2,132.59 92.46,132.33 92.46,130.05 D12:R44.2 | 101.85,131.06 99.95,129.03 | D12:D41.3 99.31,129.03
  Top 0.305: D12:R45.2 92.2,132.59 | D12:R44.2 D12:C44.2 95.65,128.78 D12:R48.2 97.59,129.08 98.55,129.03 99.31,129.03 99.95,129.03 | X3.A6 142.88,143.51 109.47,143.51 105.03,139.19 104.39,136.65 101.85,131.06
ON13
  Top 0.254: 45.21,131.32 45.47,131.06 45.47,129.43 D13:R44.2 | D13:D41.3 52.58,127.28
  Top 0.305: D13:R44.2 D13:C44.2 48.66,127.51 D13:R48.2 50.21,127.28 52.58,127.28 54.61,127.28 58.8,126.36 100.08,126.36 111.51,137.79 134.24,137.79 134.87,138.43 139.95,138.43 140.33,139.06 140.33,140.72 X3.C6 | D13:R45.2 45.21,131.32
ON14  (via drill 0.6)
  Top 0.254: D15:R45.2 45.47,118.62 45.47,116.08 D15:R44.2 D15:C44.2 48.01,114.81 48.32,115.13 48.94,115.13 D15:R48.2 | D15:D41.3 52.45,115.11
  Top 0.305: D15:R48.2 50.59,115.11 52.45,115.11 55.24,115.11 56.13,116.33 56.13,119.38 57.28,120.02 60.58,120.02 v63.12,123.19 | v69.47,123.32 73.28,123.83 99.31,123.83 109.6,134.11 136.27,134.11 138.05,135.89 142.88,135.89 X3.A3
  Route2 0.305: v63.12,123.19 66.93,123.19 v69.47,123.32
ON15  (via drill 0.5)
  Top 0.254: D14:R45.2 92.46,117.35 92.46,114.81 D14:R44.2 D14:C44.2 95,113.54 95.31,113.86 95.93,113.86 D14:R48.2 | D14:D41.3 99.19,114.3 99.18,113.81
  Top 0.305: D14:R48.2 97.59,113.84 99.18,113.81 100.08,113.79 102.23,114.43 102.36,121.79 112.01,131.44 135.51,131.44 v136.14,130.81
  Route2 0.305: v136.14,130.81 136.78,131.7 X3.C3
ON16
  Top 0.254: D16:R45.2 45.47,102.11 45.47,99.57 D16:R44.2 D16:C44.2 48.01,98.3 48.32,98.61 48.94,98.61 D16:R48.2 | D16:D41.3 52.57,98.58
  Top 0.305: D16:R48.2 52.57,98.58 57.02,98.55 57.02,104.27 57.78,105.41 95.76,105.41 106.3,95.38 106.3,80.01 119.63,66.8 134.24,66.8 134.87,69.22 136.78,71.12 143.76,71.12 144.4,70.48 144.4,70.1 X4.A24
ON17
  Top 0.254: D17:R45.2 81.66,99.19 81.66,96.65 D17:R44.2 D17:C44.2 84.2,95.38 84.52,95.69 85.14,95.69 D17:R48.2 | D17:D41.3 88.65,95.89
  Top 0.305: X4.C24 136.78,69.85 136.78,67.31 135.51,66.04 118.36,66.04 102.49,81.92 102.49,93.34 99.95,95.89 88.65,95.89 85.58,95.89 D17:R48.2
ON18  (via drill 0.6)
  Top 0.254: D18:R45.2 45.47,90.93 45.47,88.39 D18:R44.2 D18:C44.2 48.01,87.12 48.32,87.44 48.94,87.44 D18:R48.2 | D18:D41.3 52.57,87.41
  Top 0.305: D18:R48.2 50.85,87.42 52.19,87.41 | 52.19,87.41 52.57,87.41 56.39,87.38 56.9,88.27 56.9,92.33 57.4,92.71 96.14,92.71 99.95,88.9 99.95,80.64 117.73,62.87 v132.97,62.87 | 52.22,87.44 52.19,87.41
  Route2 0.305: v132.97,62.87 134.87,62.87 135.51,63.5 142.88,63.5 X4.A21
ON19  (via drill 0.6)
  Top 0.254: D19:R45.2 81.66,87.76 81.66,85.22 D19:R44.2 D19:C44.2 84.2,83.95 84.52,84.26 85.14,84.26 D19:R48.2
  Top 0.305: D19:R48.2 88.39,84.25 | 88.39,84.25 91.11,84.25 91.57,84.45 v92.2,84.45 | v95.12,84.45 96.77,84.45 98.04,83.19 98.04,80.64 116.46,62.23 130.43,62.23 131.06,61.59 136.14,61.59 136.78,62.23 X4.C21 | D19:D41.3 88.52,84.38 88.39,84.25
  Route2 0.305: v92.2,84.45 v95.12,84.45
ON20  (via drill 0.6)
  Top 0.254: D20:R45.2 46.74,75.44 46.74,72.9 D20:R44.2 D20:C44.2 49.28,71.63 49.59,71.94 50.21,71.94 D20:R48.2 | D20:D41.3 52.4,72.47
  Top 0.305: v51.82,80.64 52.96,81.28 94.23,81.28 115.19,60.33 127.89,60.33 129.79,58.42 142.62,58.42 143,58.04 143,56.01 143.89,55.12 143.89,54.86 X4.A18 | D20:R48.2 51.77,71.93 v51.82,71.88 52.4,72.47
  Route3 0.305: v51.82,71.88 v51.82,80.64
ON21  (via drill 0.6)
  Top 0.254: D21:R45.2 88.65,72.9 88.65,70.36 D21:R44.2 D21:C44.2 91.19,69.09 91.5,69.41 92.12,69.41 D21:R48.2
  Top 0.305: D21:R48.2 94.74,69.39 | 94.74,69.39 95.58,69.39 v95.76,69.22 | v101.6,69.47 116.46,54.61 X4.C18 | D21:D41.3 94.74,69.39
  Route2 0.305: v95.76,69.22 99.82,69.22 v101.6,69.47
ON22
  Top 0.254: D22:R45.2 45.47,64.01 45.47,61.47 D22:R44.2 D22:C44.2 48.01,60.2 48.32,60.52 48.94,60.52 D22:R48.2 49.99,60.88 50.55,60.96 52.58,60.96 | 52.58,60.96 57.66,60.96 59.18,64.01 64.52,64.01 64.64,64.14 | D22:D41.3 52.58,60.96
  Top 0.305: 64.64,64.14 68.83,67.31 99.95,67.31 113.92,53.34 135.51,53.34 138.05,50.8 142.37,50.8 142.88,50.29 142.88,48.26 X4.A15
ON23
  Top 0.254: D23:R45.2 92.46,61.47 92.46,58.93 D23:R44.2 D23:C44.2 95,57.66 95.31,57.98 95.93,57.98 D23:R48.2
  Top 0.305: X4.C15 116.46,46.99 106.05,57.53 99.31,57.53 | 99.31,57.53 96.63,57.53 D23:R48.2 | D23:D41.3 99.31,57.53
ON24  (via drill 0.6)
  Top 0.254: D24:R45.2 45.47,48.77 45.47,46.23 D24:R44.2 D24:C44.2 48.01,44.96 48.32,45.28 48.94,45.28 D24:R48.2
  Top 0.305: v50.67,52.83 57.02,52.83 58.42,52.45 58.67,52.45 60.58,53.98 105.03,53.98 117.73,43.18 141.86,43.18 142.88,42.93 142.88,40.64 X4.A12 | D24:R48.2 50.5,45.26 v50.67,45.09 50.67,45.16 D24:D41.3
  Route3 0.305: v50.67,45.09 v50.67,52.83
ON25  (via drill 0.6)
  Top 0.254: D25:R45.2 92.46,46.74 92.46,44.2 D25:R44.2 D25:C44.2 95,42.93 95.31,43.24 95.93,43.24 D25:R48.2
  Top 0.305: D25:R48.2 v98.04,43.18 99.31,44.45 D25:D41.3 | v105.79,43.81 107.44,43.18 112.01,43.18 120.9,37.47 137.41,37.47 X4.C12
  Route2 0.305: v98.04,43.18 104.9,43.18 v105.79,43.81
ON26  (via drill 0.6)
  Top 0.254: D26:R45.2 45.47,37.34 45.47,34.8 D26:R44.2 D26:C44.2 48.01,33.53 48.32,33.85 48.94,33.85 D26:R48.2 | D26:D41.3 52.58,34.8
  Top 0.305: v51.05,41.4 52.2,41.4 52.7,40.89 63.5,40.89 63.88,41.27 110.74,41.27 120.27,35.56 142.11,35.56 142.88,35.18 142.88,33.15 X4.A9 | D26:R48.2 50.97,33.83 v51.05,33.91 51.61,33.91 D26:D41.3
  Route3 0.305: v51.05,33.91 v51.05,41.4
ON27
  Top 0.254: D27:R45.2 92.46,35.31 92.46,32.77 D27:R44.2 D27:C44.2 95,31.5 95.31,31.81 95.93,31.81 D27:R48.2
  Top 0.305: D27:R48.2 98.68,31.75 101.35,31.75 | 101.35,31.75 X4.C9 | D27:D41.3 101.35,31.75
ON28  (via drill 0.6)
  Top 0.254: D28:R45.2 46.1,24 46.1,21.46 D28:R44.2 D28:C44.2 48.64,20.19 48.96,20.51 49.58,20.51 D28:R48.2 | D28:D41.3 52.53,21.67 v51.18,20.32
  Top 0.305: D28:R48.2 50.59,20.5 51.31,20.45 v51.18,20.32 | v51.18,29.21 52.32,29.21 54.86,30.48 69.47,30.48 70.74,29.21 85.34,29.21 86.61,27.94 125.22,27.94 126.75,29.97 129.79,29.97 131.83,27.94 141.86,27.94 142.88,27.43 142.88,25.53 X4.A6
  Route3 0.305: v51.18,20.32 v51.18,29.21
ON29  (via drill 0.6)
  Top 0.254: D29:R45.2 92.46,21.08 92.46,18.54 D29:R44.2 D29:C44.2 95,17.27 95.31,17.59 95.93,17.59 D29:R48.2
  Top 0.305: v97.92,25.15 104.65,23.5 137.41,23.5 X4.C6 | D29:D41.3 98.5,17.6 v97.92,17.53 97.11,17.57 D29:R48.2
  Route3 0.305: v97.92,17.53 v97.92,25.15
ON30
  Top 0.254: D30:R45.2 46.1,12.57 46.1,10.03 D30:R44.2 D30:C44.2 48.64,8.76 48.96,9.08 49.58,9.08 D30:R48.2
  Top 0.305: D30:R48.2 51.23,9.07 53.09,9.09 | 53.09,9.09 57.4,9.14 57.91,14.86 58.42,15.88 100.71,15.88 104.65,21.59 134.24,21.59 135.51,20.32 142.11,20.32 142.88,19.68 142.88,18.16 X4.A3 | D30:D41.3 53.09,9.1 53.09,9.09
ON31  (via drill 0.6)
  Top 0.254: D31:R45.2 92.46,9.4 92.46,6.86 D31:R44.2 D31:C44.2 95,5.59 95.31,5.91 95.93,5.91 D31:R48.2 | D31:D41.3 99.31,5.97
  Top 0.305: D31:R48.2 96.77,5.97 99.31,5.97 101.47,5.97 102.62,6.48 103.63,14.61 106.55,19.05 132.33,19.05 v136.02,14.73
  Route2 0.305: v136.02,14.73 X4.C3
OP0  (via drill 0.6)
  Top 0.254: D0:C34.2 D0:R34.2 47.39,212.6 D0:R35.1 48.64,212.3 D0:R38.1 | D0:D31.3 51.05,211.66
  Top 0.305: D0:R38.1 51.05,211.66 51.26,211.66 52.83,213.23 53.97,213.23 55.12,212.85 104.39,212.72 109.47,207.65 109.47,188.59 110.11,187.96 133.6,187.96 v134.87,189.23
  Route2 0.305: v134.87,189.23 142.49,189.23 142.88,188.85 142.88,186.94 143.13,186.69 X3.A23
OP1
  Top 0.254: D1:C34.2 D1:R34.2 94.38,210.31 D1:R35.1 95.63,210.01 D1:R38.1
  Top 0.305: D1:R38.1 98.3,209.38 | 98.3,209.38 104.57,209.38 106.3,207.65 106.3,187.96 108.84,185.42 138.68,185.42 139.32,184.78 139.32,185.17 X3.C23 | D1:D31.3 98.3,209.38
OP2  (via drill 0.6)
  Top 0.254: D2:C34.2 D2:R34.2 47.39,201.17 D2:R35.1 48.64,200.87 D2:R38.1
  Top 0.305: v135.51,184.15 134.24,183.01 108.08,183.01 104.78,187.83 104.78,199.26 103.51,200.79 52.32,200.66 50.41,200.18 | 50.41,200.18 50.29,200.15 49.48,200.03 D2:R38.1 | D2:D31.3 51.05,199.54 50.41,200.18
  Route2 0.305: v135.51,184.15 142.49,184.15 143,183.64 143,179.07 142.88,179.2 X3.A20
OP3
  Top 0.254: D3:C34.2 D3:R34.2 94.38,198.37 D3:R35.1 95.63,198.07 D3:R38.1 | D3:D31.3 98.3,196.09 97.79,196.6 97.79,198.75
  Top 0.305: D3:R38.1 96.68,197.74 97.21,198.75 97.79,198.75 101.47,198.75 102.11,197.36 101.98,184.28 105.16,180.97 137.41,180.97 138.05,181.61 139.95,181.61 140.21,181.36 140.21,178.94 X3.C20
OP4  (via drill 0.6)
  Top 0.254: D4:C34.2 D4:R34.2 47.39,185.93 D4:R35.1 48.64,185.62 D4:R38.1 | D4:D31.3 51.05,182.88 50.67,183.26 50.67,184.86 50.55,184.99
  Top 0.305: D4:R38.1 50.55,184.99 51.13,184.99 51.56,185.42 53.09,185.42 53.85,185.04 69.04,184.99 70.74,186.69 96.77,186.69 105.03,178.44 136.14,178.44 v136.78,177.8 | X3.A17 143.76,170.18 142.49,171.45 140.97,171.45 140.46,171.96 140.46,173.48 139.95,173.99 137.41,173.99 v136.91,174.5
  Route3 0.305: v136.91,174.5 136.91,177.67 v136.78,177.8
OP5  (via drill 0.4)
  Top 0.254: D5:C34.2 D5:R34.2 94.38,183.39 D5:R35.1 95.63,183.09 D5:R38.1 | D5:D31.3 98.3,180.64 97.6,181.34 97.6,182.06 v97.54,182.12
  Top 0.305: D5:R38.1 97.2,182.45 v97.54,182.12 | X3.C17 136.14,170.18 131.06,175.26 106.3,175.26 105.28,174.62 v98.04,174.62
  Route3 0.254: v97.54,182.12 98.04,175.51
  Route3 0.305: 98.04,175.51 v98.04,174.62
OP6  (via drill 0.6)
  Top 0.254: D6:C34.2 D6:R34.2 47.39,173.23 D6:R35.1 48.64,172.93 D6:R38.1
  Top 0.305: D6:R38.1 49.61,172.29 50.04,172.72 | 50.04,172.72 50.55,173.23 54.61,173.23 55.12,172.72 56.13,172.21 57.86,172.16 59.94,173.99 96.77,173.99 97.54,173.48 105.79,173.48 106.93,172.34 106.93,167 107.57,166.37 132.33,166.37 v134.24,167 | D6:D31.3 50.55,171.63 50.55,172.21 50.04,172.72
  Route2 0.305: X3.A14 143.13,163.83 143,163.83 143.13,165.74 142.49,166.37 136.14,166.37 v134.24,167
OP7
  Top 0.254: D7:C34.2 D7:R34.2 94.38,171.96 D7:R35.1 95.63,171.66 D7:R38.1 | D7:D31.3 97.79,170.18 97.79,171.02
  Top 0.305: D7:R38.1 97.79,171.02 101.01,171.02 102.87,170.18 102.87,165.74 103.63,164.47 137.16,164.47 X3.C14
OP8  (via drill 0.6)
  Top 0.254: D8:C34.2 D8:R34.2 47.39,160.53 D8:R35.1 48.64,160.23 D8:R38.1
  Top 0.305: D8:R38.1 50.91,160.34 | 50.91,160.34 51.05,160.4 55.88,161.8 122.17,161.93 v134.24,161.93 | D8:D31.3 51.05,158.55 51.05,159.51 50.91,159.66 50.91,160.34
  Route2 0.305: v134.24,161.93 138.68,158.75 142.24,158.75 143,157.73 143.13,156.21 X3.A11
OP9
  Top 0.254: D9:C34.2 D9:R34.2 94.38,159.26 D9:R35.1 95.63,158.96 D9:R38.1 | D9:D31.3 98.3,158.29
  Top 0.305: D9:R38.1 97.29,158.31 | 97.29,158.31 98.3,158.29 102.74,158.24 104.14,154.94 X3.C11 | 97.28,158.3 97.29,158.31
OP10  (via drill 0.6)
  Top 0.254: D10:C34.2 D10:R34.2 49.93,147.19 D10:R35.1 51.18,146.89 D10:R38.1 | D10:D31.3 54.1,146.05
  Top 0.305: D10:R38.1 52.25,146.05 54.1,146.05 54.36,146.05 55.12,146.81 62.74,146.81 v63.25,145.92 | v75.82,148.59 76.45,149.22 112.65,149.22 113.92,150.5 135.51,150.5 v135.51,149.86
  Route2 0.305: v63.25,145.92 69.09,146.3 v75.82,148.59 | X3.A8 144.14,147.57 143.13,148.59 143.13,150.5 142.49,151.13 136.78,151.13 v135.51,149.86
OP11
  Top 0.254: D11:C34.2 D11:R34.2 94.38,146.56 D11:R35.1 95.63,146.26 D11:R38.1 | D11:D31.3 98.3,146.05
  Top 0.305: D11:R38.1 96.27,145.54 96.14,145.41 96.27,145.41 96.9,146.05 98.3,146.05 104.14,146.05 105.16,145.54 134.24,145.41 136.14,147.32 X3.C8
OP12  (via drill 0.5)
  Top 0.254: D12:D31.3 97.79,134.62 97.66,135.51
  Top 0.305: D12:C34.2 D12:R34.2 94.38,136.4 D12:R35.1 95.63,136.09 D12:R38.1 97.66,135.51 97.66,136.14 99.01,137.87 v102.11,137.54 | v106.93,139.7 110.11,142.88 134.24,142.88 v134.87,142.24
  Route2 0.305: v134.87,142.24 136.14,143.51 142.49,143.51 142.75,143.26 142.75,141.1 X3.A5
  BOTTOM 0.305: v102.11,137.54 v106.93,139.7
OP13
  Top 0.254: D13:D31.3 51.56,134.19
  Top 0.305: D13:C34.2 D13:R34.2 47.39,135.13 D13:R35.1 48.64,134.83 D13:R38.1 51.56,134.19 57.71,134.19 59.31,127 99.44,127 110.87,138.43 133.6,138.43 134.87,139.7 X3.C5
OP14  (via drill 0.6)
  Top 0.254: D15:C34.2 D15:R34.2 47.39,122.43 D15:R35.1 48.64,122.13 D15:R38.1 | D15:D31.3 50.55,120.9 50.55,121.49
  Top 0.305: D15:R38.1 50.55,121.49 50.75,121.49 51.18,121.92 59.77,121.92 v60.32,121.54 | v72.01,122.56 99.31,122.56 110.11,133.35 142.88,133.35 X3.A2
  Route2 0.305: v60.32,121.54 70.1,121.28 v72.01,122.56
OP15
  Top 0.254: D14:C34.2 D14:R34.2 94.38,121.16 D14:R35.1 95.63,120.86 D14:R38.1 | D14:D31.3 98.3,120.76
  Top 0.305: D14:R38.1 96.6,120.22 97.16,120.78 97.29,120.78 97.8,120.77 | 97.8,120.77 98.3,120.76 100.03,120.73 111.38,132.08 X3.C2 | 97.77,120.73 97.8,120.77
OP16  (via drill 0.6)
  Top 0.254: D16:C34.2 D16:R34.2 47.39,105.92 D16:R35.1 48.64,105.61 D16:R38.1 | D16:D31.3 51.56,106.05
  Top 0.305: D16:R38.1 51.05,106.05 51.56,106.05 96.39,106.05 106.93,96.01 106.93,80.64 120.27,67.44 132.33,67.44 v132.97,68.58
  Route2 0.254: 143.13,68.58 143.13,68.33
  Route2 0.305: v132.97,68.58 143.13,68.58 | 143.13,68.33 X4.A23
OP17  (via drill 0.6)
  Top 0.254: D17:C34.2 D17:R34.2 83.58,103 D17:R35.1 84.84,102.69 D17:R38.1 | D17:D31.3 87.63,101.6 86.49,102.74 86.49,102.93
  Top 0.305: D17:R38.1 86.41,102.86 86.49,102.93 86.66,103.08 87.25,103.76 v92.46,103.76 | v93.09,94.61 93.73,95.25 99.31,95.25 101.85,92.71 101.85,81.28 117.73,65.41 137.16,65.41 X4.C23
  Route3 0.305: v92.46,103.76 92.2,95.89 v93.09,94.61
OP18
  Top 0.254: D18:C34.2 D18:R34.2 47.39,94.74 D18:R35.1 48.64,94.44 D18:R38.1 | D18:D31.3 51.56,93.81
  Top 0.305: D18:R38.1 51.56,93.81 60.12,93.81 60.58,93.34 96.77,93.34 100.58,89.53 100.58,81.28 118.36,63.5 129.79,63.5 130.43,64.14 135.51,64.14 136.14,63.5 142.49,63.5 142.88,63.25 142.88,60.71 143.51,60.33 X4.A20
OP19
  Top 0.254: D19:C34.2 D19:R34.2 83.58,91.57 D19:R35.1 84.84,91.26 D19:R38.1
  Top 0.305: D19:R38.1 87.63,90.63 | 87.63,90.63 93.01,90.63 93.6,90.04 93.6,83.82 94.23,83.19 96.14,83.19 97.41,81.92 97.41,80.01 115.82,61.59 129.79,61.59 131.06,60.33 138.43,60.33 X4.C20 | D19:D31.3 87.63,90.63
OP20
  Top 0.254: D20:C34.2 D20:R34.2 48.66,79.25 D20:R35.1 49.91,78.94 D20:R38.1 | D20:D31.3 52.4,76.38 52.07,76.71 52.07,77.79 51.44,78.42
  Top 0.305: D20:R38.1 51.26,78.31 51.44,78.42 51.79,78.66 54.86,80.64 93.6,80.64 114.55,59.69 127.25,59.69 129.16,57.78 135.51,57.78 137.41,55.88 139.83,55.88 140.33,55.37 140.33,53.59 140.59,53.34 143.13,53.34 143.76,52.7 143.76,52.45 X4.A17
OP21
  Top 0.254: D21:C34.2 D21:R34.2 90.57,76.71 D21:R35.1 91.82,76.41 D21:R38.1
  Top 0.305: D21:R38.1 94.23,75.77 | 94.23,75.77 96.82,75.77 99.19,73.03 99.19,69.85 100.97,68.07 101.73,68.07 115.82,53.98 137.16,53.98 X4.C17 | D21:D31.3 94.23,75.77
OP22  (via drill 0.6)
  Top 0.254: D22:C34.2 D22:R34.2 47.39,67.82 D22:R35.1 48.64,67.52 D22:R38.1 | D22:D31.3 51.56,66.88 51.56,66.89
  Top 0.305: D22:R38.1 50.21,66.88 51.06,66.88 51.56,66.89 v66.17,66.93 | v66.29,63.5 69.47,66.67 99.31,66.67 113.28,52.7 134.87,52.7 137.41,50.16 137.41,48.9 138.05,48.26 139.7,48.26 140.33,47.62 140.33,45.97 140.59,45.72 143.13,45.72 143.76,45.09 143.76,44.83 X4.A14
  Route3 0.305: v66.17,66.93 v66.29,63.5
OP23  (via drill 0.6)
  Top 0.254: D23:C34.2 D23:R34.2 94.38,65.28 D23:R35.1 95.63,64.97 D23:R38.1
  Top 0.305: D23:R38.1 97.2,64.34 97.28,64.26 v98.04,64.26 98.3,64.01 D23:D31.3 | X4.C14 137.16,46.35 115.82,46.35 106.93,55.24 v98.04,55.24
  Route3 0.305: v98.04,55.24 v98.04,64.26
OP24
  Top 0.254: D24:C34.2 D24:R34.2 47.39,52.58 D24:R35.1 48.64,52.28 D24:R38.1
  Top 0.305: D24:R38.1 51.31,51.64 | 51.31,51.64 59.52,51.64 61.21,53.34 104.39,53.34 114.55,44.45 117.09,42.55 135.51,42.55 137.41,40.64 139.32,40.64 140.33,40.01 140.33,38.48 140.59,38.1 143.13,38.1 X4.A11 | D24:D31.3 51.31,51.64
OP25
  Top 0.254: D25:C34.2 D25:R34.2 94.38,50.55 D25:R35.1 95.63,50.24 D25:R38.1
  Top 0.305: D25:R38.1 98.3,49.62 | 98.3,49.62 103.38,49.66 104.52,42.55 111.38,42.55 120.27,36.83 X4.C11 | D25:D31.3 98.3,49.62
OP26
  Top 0.254: D26:C34.2 D26:R34.2 47.39,41.15 D26:R35.1 48.64,40.85 D26:R38.1 | D26:D31.3 51.56,40.21
  Top 0.305: D26:R38.1 51.56,40.21 63.96,40.21 64.39,40.64 110.11,40.64 119.63,34.92 135.51,34.92 137.41,33.02 139.57,33.02 140.33,32.51 140.33,30.86 141.35,30.48 143.13,30.48 X4.A8
OP27  (via drill 0.6)
  Top 0.254: D27:C34.2 D27:R34.2 94.38,39.12 D27:R35.1 95.63,38.81 D27:R38.1
  Top 0.305: D27:R38.1 98.04,38.1 98.17,37.07 | 98.17,37.07 v98.17,36.07 | v98.68,29.84 100.58,31.11 136.78,31.11 X4.C8 | D27:D31.3 98.37,37.26 98.17,37.07
  Route3 0.305: v98.17,36.07 v98.68,29.84
OP28
  Top 0.254: D28:C34.2 D28:R34.2 48.02,27.81 D28:R35.1 49.28,27.51 D28:R38.1 | D28:D31.3 52.07,27.03 51.83,27.27
  Top 0.305: D28:R38.1 51.26,26.88 51.83,27.27 55.5,29.84 68.83,29.84 70.1,28.57 84.07,28.57 85.98,27.3 126.37,27.3 127.25,28.96 129.29,28.96 130.94,27.3 136.14,27.3 138.05,25.4 139.7,25.4 140.33,24.89 140.33,23.24 140.72,22.86 143.13,22.86 X4.A5
OP29
  Top 0.254: D29:C34.2 D29:R34.2 94.38,24.89 D29:R35.1 95.63,24.59 D29:R38.1
  Top 0.305: D29:R38.1 97.81,23.9 | 97.81,23.9 98.68,23.88 100.33,22.86 138.05,22.86 X4.C5 | D29:D31.3 98.12,22.53 97.79,22.86 97.79,23.89 97.81,23.9
OP30  (via drill 0.6)
  Top 0.254: D30:C34.2 D30:R34.2 48.02,16.38 D30:R35.1 49.28,16.08 D30:R38.1
  Top 0.305: D30:R38.1 51.48,15.45 v51.69,15.24 52.07,14.86 D30:D31.3 | v59.82,14.61 60.45,15.24 101.35,15.24 105.28,20.95 132.97,20.95 136.78,17.78 139.45,17.78 140.33,17.27 140.33,15.75 140.84,15.24 143.13,15.24 X4.A2
  Route2 0.305: v51.69,15.24 59.18,15.24 v59.82,14.61
OP31
  Top 0.254: D31:C34.2 D31:R34.2 94.38,13.21 D31:R35.1 95.63,12.9 D31:R38.1 96.6,12.19 | D31:D31.3 98.3,13.21
  Top 0.305: D31:R38.1 96.77,13.21 98.3,13.21 101.85,13.21 105.92,19.68 132.97,19.68 X4.C2
POWEN  (via drill 0.6)
  Top 0.406: v125.6,105.28 R26.2
  Route2 0.305: v142.75,103.5 130.81,103.5 130.3,104.14 129.29,104.65 126.75,104.65 126.11,105.28 v125.6,105.28
  Route3 0.305: 142.88,76.2 142.75,99.57 v142.75,103.5
  Route3 0.406: v131.06,129.54 130.99,113.89 129.18,112.5 v125.6,105.28 | X4.A26 142.88,76.2
  BOTTOM 0.254: R6.2 130.92,129.91 v131.06,129.54
POWENP  (via drill 0.6)
  Top 0.305: R23.2 118.39,105.45 | R23.2 118.38,105.41 119.63,105.41 119.76,104.78 R26.1 121.16,104.71 121.16,103.63 121.92,102.87 v121.54,102.87 R50.1 | U21.1 R23.2 | v125.98,93.34 128.52,93.34 U22.1
  Route3 0.305: v121.54,102.87 125.6,101.73 126.62,100.58 126.62,94.61 125.98,93.98 v125.98,93.34
SCL1  (via drill 0.5, 0.6)
  Top 0.254: U5.8 R51.1 117.08,204.47 v113.16,204.47 | U2.2 62.86,189.1 62.99,189.23 v62.99,190.5
  Top 0.305: U1.2 17.91,190.37 18.8,189.99 v19.3,187.32 | U6.2 17.91,138.94 19.3,139.7 v19.3,141.1 | U7.2 64.26,141.48 64.39,141.6 v64.39,143.51
  Route2 0.254: 109.22,201.29 73.28,201.29 70.74,198.75 v62.36,198.75 | v19.3,187.32 19.94,186.69 23.75,186.69 25.65,188.59 50.42,188.59 51.69,189.87 57.4,189.87 58.04,190.5 v62.99,190.5
  Route2 0.305: 109.22,201.29 110.11,201.29 T5.2 113.16,204.34 v113.16,204.47
  Route3 0.254: v62.99,190.5 v62.36,198.75
  Route3 0.305: v19.3,187.32 v19.3,141.1 | v64.39,143.51 64.39,186.06 63.12,187.32 63.12,190.37 v62.99,190.5
SCL2  (via drill 0.6)
  Top 0.254: U13.8 v120.27,82.55 119.63,81.28 U4.5
  Top 0.305: v108.84,82.55 110.11,85.08 R48.1 | v61.21,76.83 61.21,75.56 61.09,75.44 U10.2 | U9.2 18.54,77.98 18.67,78.11 v18.67,80.01 | v17.4,31.11 17.4,29.21 17.27,29.08 U11.2 | U12.2 62.36,23.37 62.48,23.5 62.48,24.13 v59.94,26.67
  Route2 0.254: v120.27,82.55 v108.84,82.55
  Route2 0.305: v108.84,82.55 107.57,82.55 105.41,84.71 | 61.21,80.64 98.55,80.64 99.19,80.64 103.38,84.84 | v18.67,80.01 18.67,80.64 20.57,82.55 59.31,82.55 61.21,80.64 | v61.21,79.38 61.21,80.64 | T8.2 105.41,84.84
  Route2 0.406: 103.38,84.84 T8.2 | 105.41,84.84 105.41,84.71
  Route3 0.305: v61.21,79.38 v61.21,76.83 60.58,76.2 60.58,73.03 61.21,72.39 61.21,28.57 59.94,27.3 v59.94,26.67 | v18.67,80.01 18.67,32.38 v17.4,31.11
SCL_EXT1
  Top 0.254: X7.3 U5.5
  Top 0.305: X3.C29 137.41,202.56 R20.1 X7.3
SCL_EXT2  (via drill 0.6)
  Top 0.254: 132.33,83.82 X5.3 | R37.1 134.87,85.09
  Top 0.305: U13.5 125.35,83.82 v125.98,83.82 X5.3 133.6,83.82 134.87,85.09 | X4.C29 137.41,83.82 137.41,85.09 R37.1 | U20.2 109.14,98.75 v109.47,95.25
  Route2 0.305: v110.74,90.17 118.36,88.9 120.27,88.27 v125.98,88.27
  Route3 0.305: v109.47,95.25 v110.74,90.17 | v125.98,83.82 v125.98,88.27
SDA1  (via drill 0.5, 0.6)
  Top 0.254: U5.1 R49.1 113.92,201.29 v113.28,201.29 | U2.3 v64.01,188.59
  Top 0.305: U1.3 17.65,189.87 18.03,189.48 v18.03,186.06 | U6.3 18.03,138.43 18.67,137.79 18.67,137.16 18.03,136.53 v18.03,135.89 | U7.3 65.02,140.97 65.66,141.6 v65.66,144.15
  Route2 0.254: 109.35,199.39 94.23,199.39 93.6,198.75 65.02,198.12 64.64,198.12 v64.01,196.85 | v18.03,186.06 25.02,186.06 26.29,187.96 52.96,187.96 53.59,188.59 v64.01,188.59
  Route2 0.305: 109.35,199.39 110.74,199.39 | 110.74,199.39 T5.1 | 110.74,199.39 111.38,199.39 v113.28,201.29
  Route3 0.254: v64.01,196.85 v64.01,188.59
  Route3 0.305: v18.03,186.06 v18.03,135.89 | v65.66,144.15 65.66,186.94 v64.01,188.59
SDA2  (via drill 0.6)
  Top 0.305: U13.1 v120.02,79.88 U4.4 R47.1 | v61.85,73.66 61.85,74.3 61.21,74.93 U10.3 | U9.3 19.3,77.47 19.94,78.11 19.94,80.01 v21.21,81.28 | U11.3 18.16,28.57 18.42,28.83 18.42,32.13 18.54,32.26 19.81,32.26 v19.94,32.38 | U12.3 63.12,22.86 63.75,23.5 63.75,24.77 v61.85,26.67
  Route2 0.305: v21.21,81.28 49.53,81.28 49.66,81.92 57.4,81.92 58.67,80.64 58.67,80.01 59.94,78.74 59.94,78.11 61.85,78.11 v62.48,78.74 63.75,80.01 100.33,80.01 102.62,82.3 T8.1 106.81,79.88 v120.02,79.88
  Route3 0.305: v62.48,78.74 62.48,74.3 v61.85,73.66 v61.85,26.67 | v19.94,32.38 19.94,80.01 v21.21,81.28
SDA_EXT1
  Top 0.254: X7.2 U5.4 | 142.49,199.39 R14.1 135.51,200.66 134.24,200.66
  Top 0.305: X3.A29 142.49,199.39 | 134.24,200.66 X7.2
SDA_EXT2  (via drill 0.6)
  Top 0.305: X4.A29 143.13,81.28 137.41,81.28 136.78,80.01 R34.1 134.24,80.01 X5.2 127.25,81.28 126.62,80.64 v124.71,80.64 123.39,80.64 U13.4 | U20.1 108.46,99.57 107.32,99.06 v106.81,99.06
  Route2 0.305: v108.71,88.27 122.81,87 v124.71,87
  Route3 0.305: v106.81,99.06 v108.71,88.27 | v124.71,87 v124.71,80.64
TALERT  (via drill 0.6)
  Top 0.254: X4.C26 139.06,75.18 | 136.16,76.83 R12.2
  Top 0.305: U20.3 109.8,98.22 109.98,98.04 111.76,98.04 v112.01,97.79 | v137.41,78.74 136.14,77.47 R12.2 | 139.06,75.18 137.41,76.83 136.16,76.83
  Route2 0.305: v112.01,97.79 117.09,97.79 119,99.69 127.89,99.69 128.52,100.33 131.7,100.33 132.33,99.69 v136.14,99.69
  Route3 0.254: v136.14,99.69 136.14,79.38 136.78,79.38 v137.41,78.74
TIDA0
  Top 0.254: U20.7 109.22,104.65 R7.1 110.87,106.17 111.38,106.3 111.63,106.3 T6.1
TIDA1
  Top 0.254: U20.6 109.98,104.9 111.25,104.9 111.25,104.14 T6.2
  BOTTOM 0.254: R32.1 113.41,101.98 T6.2
V1_8  (via drill 0.5, 0.6)
  Top 0.254: D18:C5.2 54.61,91.44 v53.09,92.46 D18:D31.2 D18:D41.2 | D16:C5.2 54.61,104.14 54.1,104.65 v53.09,104.65 53.09,103.12 D16:D31.2 D16:D41.2 | 53.07,211.44 53.07,210.22 D0:C5.2 53.07,209.93 52.7,209.93 51.88,209.11 D0:D31.2 51.56,208.79 51.05,208.28 50.8,208.28 50.67,208.15 50.67,207.58 D0:D41.2 | D2:D31.2 52.07,196.41 | 52.07,196.41 52.51,196.41 52.58,196.34 D2:D41.2 | 52.07,198.63 52.07,197.61 | 52.07,197.61 52.07,196.41 | D2:C5.2 52.07,197.61 | D4:D41.2 52.07,180.66 D4:D31.2 51.56,181.36 52.07,181.86 v52.07,184.02 | v99.31,197.61 99.31,195.07 98.81,194.56 D3:D31.2 98.81,193.55 99.64,192.72 D3:D41.2 | D5:C5.2 100.95,179.32 99.82,179.32 99.64,179.14 D5:D31.2 98.81,178.82 98.3,178.31 D5:D41.2 | D7:D41.2 D7:D31.2 99.31,168.66 v99.31,170.18 | D9:C5.2 v100.08,156.46 D9:D31.2 D9:D41.2 | D11:D41.2 D11:D31.2 99.82,143.26 v100.08,144.4 | D12:D41.2 D12:D31.2 99.82,133.1 D12:C5.2 | v99.57,119.13 99.31,117.35 D14:D31.2 D14:D41.2 | D17:D41.2 D17:D31.2 89.48,100.73 D17:C5.2 v90.68,102.62 | D10:D31.2 54.93,143.58 55.12,143.76 55.12,144.4 v56.01,145.29 | D13:D41.2 D13:D31.2 53.09,131.57 v53.09,132.59 | D15:D41.2 D15:D31.2 52.7,119.63 v52.7,120.4 D15:C5.2 | D20:C5.2 54.98,76.71 54.1,76.71 53.59,76.2 53.59,75.18 53.41,75 D20:D31.2 D20:D41.2 | D31:D41.2 D31:D31.2 99.64,10.48 99.82,10.67 101.2,10.67 D31:C5.2 | D22:D41.2 D22:D31.2 52.14,64.33 52.83,65.02 v53.59,65.02 54.1,65.02 54.61,65.53 D22:C5.2 | D28:D41.2 D28:D31.2 53.92,25.54 D28:C5.2 | D26:D31.2 D26:D41.2 | D30:D41.2 D30:D31.2 53.41,12.52 v54.23,13.34 | D21:C5.2 97.28,74.17 v96.27,74.17
  Top 0.305: v121.54,76.2 R38.1 118.63,71.14 v118.62,71.12 | 52.96,77.6 v53.09,77.72 54.61,77.72 55.12,77.22 D20:C5.2 | X3.C27 136.79,195.58 R58.1 134.25,191.91 v133.35,191.01 T10.2 | D5:C5.2 100.47,179.83 100.33,180.34 v99.31,181.36 | v52.07,172.21 53.21,172.21 53.58,171.85 D6:C5.2 53.35,170.32 53.34,170.31 52.89,170.31 D6:D31.2 D6:D41.2 | 53.07,211.44 v53.09,211.84 | 52.07,198.63 v52.07,199.14 | D4:C5.2 54.1,183.39 53.59,183.9 52.2,183.9 v52.07,184.02 | D8:C5.2 53.96,158.13 53.34,158.75 | 53.34,158.75 v52.58,159.51 | v56.01,145.29 D10:C5.2 | D7:C5.2 100.58,168.91 v99.31,170.18 | D13:C5.2 54.47,131.71 53.59,132.59 v53.09,132.59 | D3:C5.2 99.68,197.47 v99.31,197.61 | D1:C5.2 99.96,207.41 99.95,207.39 | D12:C5.2 100.19,135.49 v99.82,136.14 | D11:C5.2 101.2,143.91 100.84,144.27 100.71,144.27 v100.08,144.4 | D14:C5.2 100.7,119.01 100.33,119.38 99.82,119.38 v99.57,119.13 | 99.95,207.39 99.95,206.38 99.31,206.38 | 99.31,206.38 99,206.38 D1:D31.2 | D1:D41.2 99.31,206.38 | v99.95,208.03 99.95,207.39 | 53.34,158.75 53.34,158.69 D8:D31.2 51.69,155.76 D8:D41.2 | D24:D41.2 51.05,47.75 51.82,48.9 D24:D31.2 53.41,49.09 D24:C5.2 53.47,50.16 v52.96,50.67 | D26:C5.2 53.86,38.24 53.85,38.23 v53.47,38.23 53.34,38.1 52.96,38.1 52.27,37.41 D26:D31.2 | 53.92,25.54 53.92,26.09 v53.59,26.42 | D30:C5.2 v54.24,13.35 v54.23,13.34 | D19:C5.2 91.55,88.03 v90.17,89.41 89.34,89.41 D19:D31.2 88.01,88.08 D19:D41.2 | D21:D41.2 94.23,72.39 94.62,72.77 94.62,73.35 D21:D31.2 95.57,73.47 v96.27,74.17 | D23:D41.2 D23:D31.2 98.88,61.28 99.19,61.59 v100.33,61.59 100.34,61.61 D23:C5.2 | D25:D41.2 D25:D31.2 99.13,47.06 99.82,47.75 v100.33,47.75 100.7,47.39 D25:C5.2
  Top 0.305: v100.33,39.62 101.35,39.62 102.73,38.75 D27:C5.2 102,37.73 101.85,37.59 101.85,36.9 D27:D31.2 D27:D41.2 | D29:C5.2 100.34,21.48 v100.33,21.46 100.02,21.15 D29:D31.2 D29:D41.2 | v100.08,11.94 101.09,11.94 101.35,11.68 D31:C5.2
  Top 0.406: D10:D31.2 D10:D41.2
  Route2 0.305: X4.C27 123.44,77.47 122.17,76.2 v121.54,76.2 | v132.33,170.18 v99.31,170.18 96.27,171.7 96.27,173.74 58.67,173.74 57.15,172.21 v52.07,172.21 | v100.33,56.39 73.91,56.39 72.39,57.91 58.67,57.91 v53.59,59.44 | v118.62,71.12 v100.33,71.12 99.31,71.12 v96.27,74.17
  Route3 0.254: 53.59,61.98 v53.59,65.02 53.09,67.06 53.09,72.64 | v53.09,77.72 v53.09,92.46 v53.09,104.65
  Route3 0.305: v53.09,77.72 53.09,72.64 | v133.35,191.01 v132.33,170.18 | v53.09,211.84 53.09,210.31 52.07,209.3 v52.07,199.14 v52.07,184.02 v52.07,172.21 v52.58,159.51 55.12,155.96 v56.01,145.29 55.12,144.4 55.12,139.19 53.09,136.65 v53.09,132.59 52.7,132.21 v52.7,120.4 52.7,116.46 53.09,115.32 v53.09,104.65 | v99.95,208.03 99.95,203.84 99.31,203.2 v99.31,197.61 v99.31,181.36 v99.31,170.18 98.81,169.16 98.81,158.5 v100.08,156.46 v100.08,144.4 100.33,143.64 v99.82,136.14 99.72,136.04 99.72,135.66 99.06,135 v99.57,119.13 99.57,118.62 99.82,118.36 | 53.59,61.98 v53.59,59.44 52.96,54.99 v52.96,50.67 52.07,50.29 52.07,45.21 53.09,44.7 53.09,41.15 53.47,40.77 v53.47,38.23 53.59,38.1 v53.59,26.42 53.92,26.09 53.92,25.91 54.23,25.6 v54.23,13.34 | v90.68,102.62 90.17,102.62 89.66,101.6 89.66,95 90.17,94.49 v90.17,89.41 93.73,89.41 96.77,86.36 v96.27,74.17 | v100.33,71.12 v100.33,61.59 v100.33,56.39 v100.33,47.75 v100.33,39.62 v100.33,21.46 100.33,12.19 v100.08,11.94
  BOTTOM 0.305: D33.C v121.54,76.2
  BOTTOM 0.61: D32.C 130.81,190.75 T10.2
V3.3  (via drill 0.4, 0.6)
  Top 0.254: C7.1 U20.8 v108.46,101.98 | R37.2 135.51,82.55 R34.2 | U13.3 122.81,79.38 C19.1 | R46.2 X7.1 | R14.2 132.33,199.39 131.7,198.12 X7.1 | v134.87,203.84 R20.2 | U5.3 119.89,199.9 C20.1 | X7.1 122.81,198.12 122.17,198.75 C20.1 | C20.1 120.25,198.75 119.63,198.75 119,198.12 R33.2
  Top 0.305: R37.2 135.52,83.81 | v137.41,82.55 135.51,82.55
  Top 0.406: C19.1 X5.1 132.97,78.74 134.24,77.47 134.24,76.2 134.87,75.56 R12.1 136.14,74.3 136.78,73.66 142.49,73.66 142.88,73.91 142.88,76.2 X4.A27 | v134.37,135.25 v129.92,135.25
  Route2 0.254: v108.46,101.98 110.16,101.98 110.54,101.91 136.4,101.91 | X5.1 134.24,82.55 | X3.A27 143.13,196.85 133.6,196.85 132.97,198.12 X7.1
  Route2 0.305: 134.24,82.55 v137.41,82.55 | v138.94,115.82 v136.4,115.82 | 136.4,101.91 v137.41,101.6
  Route3 0.254: v137.41,101.6 v137.41,82.55 | X7.1 132.97,199.39 132.97,202.56 v134.87,203.84
  Route3 0.305: v137.41,101.6 137.41,103.63 137.92,104.14 137.92,112.27 138.43,113.79 138.94,114.81 v138.94,115.82 | v136.4,115.82 136.65,117.6
  Route3 0.406: X7.1 v129.92,135.25 | 136.65,117.6 136.65,127.76 134.37,129.54 v134.37,135.25
V5  (via drill 0.4, 0.6)