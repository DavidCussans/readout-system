# EAGLE board SOL_AMPV3 (EAGLE 7.6.0), part 4 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
LDAC8 (continued)
  Top 0.305: U12.4 59.44,22.35 LDAC8.TP 58.04,21.59 57.4,20.95 R44.2
N$1
  Top 0.305: U1.1 12.04,190.86 | 12.04,190.86 11.68,190.5 C1.1 | 12.04,190.86 12.04,192.14 R4.1
N$2
  Top 0.305: R38.2 R57.1 126.22,69.83 U17.3
N$3
  Top 0.406: LED1.C 109.25,113.9 R1.2
N$4
  Top 0.254: U20.7 109.22,104.65 R7.1 111.38,106.68 T6.TP
N$5
  Top 0.305: U14.8 122.48,124.16 122.17,124.46 121.55,124.46 R53.2 R52.2
N$6
  Top 0.305: U2.1 60.3,189.59 59.63,188.91 | 59.63,188.91 59.31,188.59 C2.1 | R10.1 59.31,189.23 59.63,188.91
N$7
  Top 0.254: R15.1 T14.TP 110.49,9.91 U3.11
N$8
  Top 0.305: U6.1 15.14,139.42 14.99,139.57 14.99,140.73 C9.1 14.86,140.86 14.86,141.6 14.61,141.86 13.84,141.86 13.57,142.13 R21.1
N$9
  Top 0.254: U3.6 113.53,12.45 113.28,12.7 112.32,13.48 R17.2
N$10
  Top 0.254: U4.6 R13.1
N$11
  Top 0.305: U7.1 60.86,141.96 60.58,142.24 | 60.58,142.24 C10.1 | R24.1 60.56,142.25 60.58,142.24
N$12
  Top 0.305: R28.1 15.49,79.36 C11.1 15.88,78.36 15.98,78.46 U9.1
N$13  (via drill 0.6)
  Top 0.254: U3.1 115.05,9.41 115.19,9.27 v115.19,7.62 | R16.1 124.06,6.97 T15.TP
  Route2 0.254: v115.19,7.62 117.73,7.62 118.36,8.26 120.27,8.26 120.9,7.62 123.44,7.62 T15.TP
N$14
  Top 0.305: R35.1 57.4,76.2 | 57.4,76.2 57.4,75.58 C12.1 | U10.1 57.68,75.92 57.4,76.2
N$15
  Top 0.305: U11.1 13.96,29.57 C13.1 13.59,29.48 13.59,30.48 14.21,31.1 R40.1
N$16
  Top 0.305: U12.1 59.04,23.85 | 59.04,23.85 58.67,23.85 R43.1 | 59.04,23.85 C14.1
N$17  (via drill 0.6)
  Top 0.406: F1.1 127.18,12.22 | 127.18,12.22 127.18,12.19 | 127.18,12.22 v127.18,12.7 | v135.79,14.43 134.01,15.29 R39.2
  Route2 0.406: v127.18,12.7 129.03,14.55 135.66,14.55 v135.79,14.43
N$18
  Top 0.305: U14.5 129.5,124.16 R54.2 R27.1 132.32,126.97 R6.1
N$19
  Top 0.305: F1.2 129.64,9.37 X6.1
N$20
  Top 0.305: U21.2 R30.1 R31.2
N$21
  Top 1.016: X8.3 F3.1
N$22
  Top 0.305: U22.2 131.97,94.87 R2.1 132.46,95.11 R3.2
N$23
  Top 0.305: R58.2 124.19,193.68 R59.1 | R59.1 122.92,190.63 C26.1 | R59.1 122.17,192.41 121.54,193.04 120.07,193.04 U19.3
N$24
  Top 0.406: R8.2 129.18,15.06 R39.1
N$25
  Top 1.016: F2.2 X8.1
N$26
  Top 0.254: U20.6 109.98,104.9 111,105.16 R32.1 T7.TP
ON0
  Top 0.254: D0:R45.2 45.47,208.79 45.47,206.25 D0:R44.2 D0:C44.2 48.01,204.98 48.32,205.3 48.94,205.3 D0:R48.2
  Top 0.305: D0:R48.2 50.59,205.28 51.69,206.38 51.69,210.82 52.96,212.09 103.76,212.09 108.84,207.01 108.84,187.96 109.47,187.32 134.87,187.32 136.78,189.23 143.13,189.23 143.76,188.59 143.76,188.34 X3.A24
ON1  (via drill 0.6)
  Top 0.254: D1:R45.2 92.46,206.5 92.46,203.96 D1:R44.2 D1:C44.2 95,202.69 95.31,203.01 95.93,203.01 D1:R48.2
  Top 0.305: D1:R48.2 103.96,202.99 v104.39,202.56 | v107.57,202.56 107.57,201.42 107.06,201.42 106.93,188.21 108.97,186.06 137.16,186.06 X3.C24
  BOTTOM 0.305: v104.39,202.56 v107.57,202.56
ON2
  Top 0.254: D2:R45.2 45.47,197.36 45.47,194.82 D2:R44.2 D2:C44.2 48.01,193.55 48.32,193.87 48.94,193.87 D2:R48.2
  Top 0.305: D2:R48.2 53.13,193.85 53.59,194.31 53.59,199.39 54.23,200.03 99.31,200.03 99.95,199.39 99.95,189.87 106.93,182.88 136.14,182.88 137.41,184.15 142.49,184.15 142.88,183.77 142.88,181.61 X3.A21
ON3
  Top 0.254: D3:R45.2 92.46,194.56 92.46,192.02 D3:R44.2 D3:C44.2 95,190.75 95.31,191.07 D3:R48.2
  Top 0.305: D3:R48.2 95.95,189.42 105.03,180.34 X3.C21
ON4
  Top 0.254: D4:R45.2 45.47,182.12 45.47,179.58 D4:R44.2 D4:C44.2 48.01,178.31 48.32,178.62 48.94,178.62 D4:R48.2
  Top 0.305: X3.A18 144.14,172.97 143,174.12 143,175.77 142.24,176.53 134.87,176.53 133.6,177.8 104.65,177.8 96.52,186.06 71.37,186.06 69.47,184.15 52.96,184.15 51.69,182.88 51.69,179.71 50.59,178.61 D4:R48.2
ON5  (via drill 0.6)
  Top 0.254: D5:R45.2 92.46,179.58 92.46,177.04 D5:R44.2 D5:C44.2 95,175.77 95.31,176.09 95.93,176.09 D5:R48.2
  Top 0.305: D5:R48.2 97.87,176.07 v98.04,175.9 | v101.85,176.53 103.12,176.53 103.76,175.9 131.7,175.9 134.87,172.72 X3.C18
  Route2 0.305: v98.04,175.9 101.22,175.9 v101.85,176.53
ON6
  Top 0.254: D6:R45.2 45.47,169.42 45.47,166.88 D6:R44.2 D6:C44.2 48.01,165.61 48.32,165.93 48.94,165.93 D6:R48.2
  Top 0.305: D6:R48.2 51.86,165.91 52.32,166.37 52.32,170.81 52.96,171.45 58.67,171.45 60.45,173.23 105.66,173.23 106.17,172.47 106.17,166.88 106.93,165.74 136.14,165.74 137.41,166.37 142.49,166.37 X3.A15
ON7
  Top 0.254: D7:R45.2 92.46,168.15 92.46,165.61 D7:R44.2 D7:C44.2 95,164.34 95.31,164.66 95.93,164.66 D7:R48.2
  Top 0.305: D7:R48.2 99.14,164.64 99.95,163.83 136.14,163.83 138.68,161.29 139.95,161.29 140.33,161.93 140.33,163.58 X3.C15
ON8
  Top 0.254: D8:R45.2 45.47,156.72 45.47,154.18 D8:R44.2 D8:C44.2 48.01,152.91 48.32,153.23 48.94,153.23 D8:R48.2
  Top 0.305: D8:R48.2 51.05,153.67 51.05,158.75 56.13,161.29 132.97,161.29 136.78,158.75 143.13,158.75 X3.A12
ON9
  Top 0.254: D9:R45.2 92.46,155.45 92.46,152.91 D9:R44.2 D9:C44.2 95,151.64 95.31,151.96 95.93,151.96 D9:R48.2
  Top 0.305: D9:R48.2 98.04,151.76 99.95,154.31 137.41,154.31 138.05,153.67 139.95,153.67 140.46,154.18 140.46,156.21 X3.C12
ON10  (via drill 0.6)
  Top 0.254: D10:R45.2 48.01,143.38 48.01,140.84 D10:R44.2 D10:C44.2 50.55,139.57 50.86,139.89 D10:R48.2
  Top 0.305: D10:R48.2 52.5,139.88 52.96,140.34 52.96,143.51 53.59,144.78 59.94,144.78 v62.48,147.32 | v72.64,149.86 112.01,149.86 113.28,151.13 143.13,151.13 143.76,150.5 143.76,150.24 X3.A9
  Route2 0.305: v62.48,147.32 68.83,147.32 v72.64,149.86
ON11
  Top 0.254: D11:R45.2 92.46,142.75 92.46,140.21 D11:R44.2 D11:C44.2 95,138.94 95.31,139.26 95.93,139.26 D11:R48.2
  Top 0.305: D11:R48.2 97.59,139.24 98.04,139.7 98.04,144.15 98.68,144.78 134.87,144.78 136.14,146.05 139.95,146.05 140.46,146.56 140.46,148.46 X3.C9
ON12
  Top 0.254: 92.2,132.59 92.46,132.33 92.46,130.05 D12:R44.2
  Top 0.305: D12:R45.2 92.2,132.59 | D12:R44.2 D12:C44.2 95.65,128.78 D12:R48.2 97.59,129.08 98.04,129.54 98.04,134.62 100.58,134.62 109.47,143.51 142.88,143.51 X3.A6
ON13
  Top 0.254: 45.21,131.32 45.47,131.06 45.47,129.43 D13:R44.2
  Top 0.305: D13:R44.2 D13:C44.2 48.66,127.51 D13:R48.2 51.23,127.81 53.59,130.81 54.23,130.81 58.8,126.36 98.04,126.36 109.47,137.79 134.24,137.79 134.87,138.43 139.95,138.43 140.33,139.06 140.33,140.72 X3.C6 | D13:R45.2 45.21,131.32
ON14  (via drill 0.6)
  Top 0.254: D15:R45.2 45.47,118.62 45.47,116.08 D15:R44.2 D15:C44.2 48.01,114.81 48.32,115.13 48.94,115.13 D15:R48.2
  Top 0.305: D15:R48.2 50.59,115.11 51.69,116.2 51.69,119.38 52.96,120.65 58.67,120.65 59.31,120.02 60.58,120.02 v63.12,123.19 | v69.47,123.32 73.28,123.83 99.31,123.83 110.11,134.62 136.78,134.62 138.05,135.89 142.88,135.89 X3.A3
  Route2 0.305: v63.12,123.19 66.93,123.19 v69.47,123.32
ON15  (via drill 0.5)
  Top 0.254: D14:R45.2 92.46,117.35 92.46,114.81 D14:R44.2 D14:C44.2 95,113.54 95.31,113.86 95.93,113.86 D14:R48.2
  Top 0.305: D14:R48.2 97.59,113.84 98.04,114.3 98.04,118.75 98.68,119.38 99.95,119.38 112.01,131.44 135.51,131.44 v136.14,130.81
  Route2 0.305: v136.14,130.81 136.78,131.7 X3.C3
ON16
  Top 0.254: D16:R45.2 45.47,102.11 45.47,99.57 D16:R44.2 D16:C44.2 48.01,98.3 48.32,98.61 48.94,98.61 D16:R48.2
  Top 0.305: D16:R48.2 50.42,99.06 50.42,104.78 51.69,105.41 95.76,105.41 106.3,95.38 106.3,80.01 119.63,67.31 134.24,67.31 134.87,69.22 136.78,71.12 143.76,71.12 144.4,70.48 144.4,70.1 X4.A24
ON17
  Top 0.254: D17:R45.2 81.66,99.19 81.66,96.65 D17:R44.2 D17:C44.2 84.2,95.38 84.52,95.69 85.14,95.69 D17:R48.2
  Top 0.305: X4.C24 136.78,69.85 136.78,67.31 135.51,66.04 118.36,66.04 102.49,81.92 102.49,93.34 99.95,95.89 85.58,95.89 D17:R48.2
ON18  (via drill 0.6)
  Top 0.254: D18:R45.2 45.47,90.93 45.47,88.39 D18:R44.2 D18:C44.2 48.01,87.12 48.32,87.44 48.94,87.44 D18:R48.2
  Top 0.305: D18:R48.2 50.85,87.42 51.69,88.27 51.69,92.71 52.32,93.34 59.31,93.34 59.94,92.71 96.14,92.71 99.95,88.9 99.95,80.64 117.73,62.87 v132.97,62.87
  Route2 0.305: v132.97,62.87 134.87,62.87 135.51,63.5 142.88,63.5 X4.A21
ON19  (via drill 0.6)
  Top 0.254: D19:R45.2 81.66,87.76 81.66,85.22 D19:R44.2 D19:C44.2 84.2,83.95 84.52,84.26 85.14,84.26 D19:R48.2
  Top 0.305: D19:R48.2 86.41,84.25 v86.61,84.45 | v91.06,84.45 96.77,84.45 98.04,83.19 98.04,80.64 116.46,62.23 130.43,62.23 131.06,61.59 136.14,61.59 136.78,62.23 X4.C21
  Route2 0.305: v86.61,84.45 v91.06,84.45
ON20  (via drill 0.6)
  Top 0.254: D20:R45.2 46.74,75.44 46.74,72.9 D20:R44.2 D20:C44.2 49.28,71.63 49.59,71.94 50.21,71.94 D20:R48.2
  Top 0.305: D20:R48.2 51.86,71.93 52.32,72.39 v52.32,77.47 | v52.32,80.64 52.96,81.28 94.23,81.28 115.19,60.33 127.89,60.33 129.79,58.42 142.62,58.42 143,58.04 143,56.01 143.89,55.12 143.89,54.86 X4.A18
  Route3 0.305: v52.32,77.47 v52.32,80.64
ON21  (via drill 0.6)
  Top 0.254: D21:R45.2 88.65,72.9 88.65,70.36 D21:R44.2 D21:C44.2 91.19,69.09 91.5,69.41 92.12,69.41 D21:R48.2
  Top 0.305: D21:R48.2 94.06,69.39 v94.23,69.22 | v98.04,70.48 99.31,69.22 101.85,69.22 116.46,54.61 X4.C18
  Route2 0.305: v94.23,69.22 96.77,69.22 v98.04,70.48
ON22  (via drill 0.6)
  Top 0.254: D22:R45.2 45.47,64.01 45.47,61.47 D22:R44.2 D22:C44.2 48.01,60.2 48.32,60.52 48.94,60.52 D22:R48.2
  Top 0.305: D22:R48.2 52.5,60.5 v54.23,62.23 | v54.86,64.77 55.5,64.77 56.13,64.14 65.66,64.14 68.83,67.31 99.95,67.31 113.92,53.34 135.51,53.34 138.05,50.8 142.37,50.8 142.88,50.29 142.88,48.26 X4.A15
  Route3 0.305: v54.23,62.23 54.23,64.14 v54.86,64.77
ON23  (via drill 0.6)
  Top 0.254: D23:R45.2 92.46,61.47 92.46,58.93 D23:R44.2 D23:C44.2 95,57.66 95.31,57.98 95.93,57.98 D23:R48.2
  Top 0.305: D23:R48.2 97.87,57.96 v98.04,57.78 | v100.58,59.05 105.03,58.42 116.46,46.99 X4.C15
  Route2 0.305: v98.04,57.78 99.95,57.78 v100.58,59.05
ON24  (via drill 0.6)
  Top 0.254: D24:R45.2 45.47,48.77 45.47,46.23 D24:R44.2 D24:C44.2 48.01,44.96 48.32,45.28 48.94,45.28 D24:R48.2
  Top 0.305: D24:R48.2 51.23,45.26 51.69,45.72 v51.69,50.16 | v51.69,53.34 51.94,53.34 52.83,52.45 58.67,52.45 60.58,53.98 105.03,53.98 117.73,43.18 141.86,43.18 142.88,42.93 142.88,40.64 X4.A12
  Route3 0.305: v51.69,50.16 v51.69,53.34
ON25  (via drill 0.6)
  Top 0.254: D25:R45.2 92.46,46.74 92.46,44.2 D25:R44.2 D25:C44.2 95,42.93 95.31,43.24 95.93,43.24 D25:R48.2
  Top 0.305: D25:R48.2 v98.04,43.18 | v101.22,43.81 101.85,43.18 112.01,43.18 120.9,37.47 137.41,37.47 X4.C12
  Route2 0.305: v98.04,43.18 v101.22,43.81
ON26  (via drill 0.6)
  Top 0.254: D26:R45.2 45.47,37.34 45.47,34.8 D26:R44.2 D26:C44.2 48.01,33.53 48.32,33.85 48.94,33.85 D26:R48.2
  Top 0.305: D26:R48.2 50.59,33.83 51.05,34.29 v51.05,38.73 | v51.05,41.91 51.69,41.91 52.7,40.89 63.5,40.89 63.88,41.27 110.74,41.27 120.27,35.56 142.11,35.56 142.88,35.18 142.88,33.15 X4.A9
  Route3 0.305: v51.05,38.73 v51.05,41.91
ON27
  Top 0.254: D27:R45.2 92.46,35.31 92.46,32.77 D27:R44.2 D27:C44.2 95,31.5 95.31,31.81 95.93,31.81 D27:R48.2
  Top 0.305: D27:R48.2 98.68,31.75 X4.C9
ON28  (via drill 0.6)
  Top 0.254: D28:R45.2 46.1,24 46.1,21.46 D28:R44.2 D28:C44.2 48.64,20.19 48.96,20.51 49.58,20.51 D28:R48.2
  Top 0.305: D28:R48.2 50.59,20.5 51.69,21.59 v51.69,25.4 | v51.69,29.21 52.32,29.21 54.86,30.48 69.47,30.48 70.74,29.21 85.34,29.21 86.61,27.94 141.86,27.94 142.88,27.43 142.88,25.53 X4.A6
  Route3 0.305: v51.69,25.4 v51.69,29.21
ON29  (via drill 0.6)
  Top 0.254: D29:R45.2 92.46,21.08 92.46,18.54 D29:R44.2 D29:C44.2 95,17.27 95.31,17.59 95.93,17.59 D29:R48.2
  Top 0.305: D29:R48.2 96.77,17.78 97.41,18.41 v98.04,22.23 | v99.95,24.13 100.58,23.5 137.41,23.5 X4.C6
  Route3 0.305: v98.04,22.23 v99.95,24.13
ON30
  Top 0.254: D30:R45.2 46.1,12.57 46.1,10.03 D30:R44.2 D30:C44.2 48.64,8.76 48.96,9.08 49.58,9.08 D30:R48.2
  Top 0.305: D30:R48.2 51.23,9.07 52.32,10.16 52.32,13.34 54.86,15.88 98.68,15.88 103.12,21.59 134.24,21.59 135.51,20.32 142.11,20.32 142.88,19.68 142.88,18.16 X4.A3
ON31  (via drill 0.6)
  Top 0.254: D31:R45.2 92.46,9.4 92.46,6.86 D31:R44.2 D31:C44.2 95,5.59 95.31,5.91 95.93,5.91 D31:R48.2
  Top 0.305: D31:R48.2 97.41,6.35 99.31,12.06 99.95,12.06 105.03,19.05 132.33,19.05 v132.46,18.29
  Route2 0.305: v132.46,18.29 X4.C3
OP0  (via drill 0.6)
  Top 0.254: D0:C34.2 D0:R34.2 47.39,212.6 D0:R35.1 48.64,212.3 D0:R38.1
  Top 0.305: D0:R38.1 51.26,211.66 52.32,212.72 104.39,212.72 109.47,207.65 109.47,188.59 110.11,187.96 133.6,187.96 v134.87,189.23
  Route2 0.305: v134.87,189.23 142.49,189.23 142.88,188.85 142.88,186.94 143.13,186.69 X3.A23
OP1
  Top 0.254: D1:C34.2 D1:R34.2 94.38,210.31 D1:R35.1 95.63,210.01 D1:R38.1
  Top 0.305: D1:R38.1 104.57,209.38 106.3,207.65 106.3,187.96 108.84,185.42 138.68,185.42 139.32,184.78 139.32,185.17 X3.C23
OP2  (via drill 0.6)
  Top 0.254: D2:C34.2 D2:R34.2 47.39,201.17 D2:R35.1 48.64,200.87 D2:R38.1
  Top 0.305: v135.51,184.15 134.24,183.51 107.06,183.51 100.58,189.99 100.58,200.03 99.95,200.66 52.32,200.66 51.69,200.03 49.48,200.03 D2:R38.1
  Route2 0.305: v135.51,184.15 142.49,184.15 143,183.64 143,179.07 142.88,179.2 X3.A20
OP3
  Top 0.254: D3:C34.2 D3:R34.2 94.38,198.37 D3:R35.1 95.63,198.07 D3:R38.1
  Top 0.305: D3:R38.1 96.82,197.44 98.04,196.22 98.04,188.09 105.16,180.97 137.41,180.97 138.05,181.61 139.95,181.61 140.21,181.36 140.21,178.94 X3.C20
OP4  (via drill 0.6)
  Top 0.254: D4:C34.2 D4:R34.2 47.39,185.93 D4:R35.1 48.64,185.62 D4:R38.1
  Top 0.305: D4:R38.1 69.04,184.99 70.74,186.69 96.77,186.69 105.03,178.44 136.14,178.44 v136.78,177.8 | X3.A17 143.76,170.18 142.49,171.45 140.97,171.45 140.46,171.96 140.46,173.48 139.95,173.99 137.41,173.99 v136.91,174.5
  Route3 0.305: v136.91,174.5 136.91,177.67 v136.78,177.8
OP5
  Top 0.254: D5:C34.2 D5:R34.2 94.38,183.39 D5:R35.1 95.63,183.09 D5:R38.1
  Top 0.305: D5:R38.1 97.2,182.45 98.04,181.61 98.04,178.44 101.22,175.26 131.06,175.26 136.14,170.18 138.68,170.18 139.32,169.54 139.32,169.93 X3.C17
OP6  (via drill 0.6)
  Top 0.254: D6:C34.2 D6:R34.2 47.39,173.23 D6:R35.1 48.64,172.93 D6:R38.1
  Top 0.305: D6:R38.1 58.24,172.29 59.94,173.99 106.3,173.99 106.93,173.35 106.93,167 107.57,166.37 132.33,166.37 v134.24,167
  Route2 0.305: X3.A14 143.13,163.83 143,163.83 143.13,165.74 142.49,166.37 136.14,166.37 v134.24,167
OP7
  Top 0.254: D7:C34.2 D7:R34.2 94.38,171.96 D7:R35.1 95.63,171.66 D7:R38.1
  Top 0.305: D7:R38.1 98.47,171.02 99.31,170.18 99.31,165.74 100.58,164.47 137.16,164.47 X3.C14
OP8  (via drill 0.6)
  Top 0.254: D8:C34.2 D8:R34.2 47.39,160.53 D8:R35.1 48.64,160.23 D8:R38.1
  Top 0.305: D8:R38.1 51.05,159.38 55.88,161.8 122.17,161.93 v134.24,161.93
  Route2 0.305: v134.24,161.93 138.68,158.75 142.24,158.75 143,157.73 143.13,156.21 X3.A11
OP9
  Top 0.254: D9:C34.2 D9:R34.2 94.38,159.26 D9:R35.1 95.63,158.96 D9:R38.1
  Top 0.305: D9:R38.1 98.68,158.12 100.58,154.94 X3.C11
OP10  (via drill 0.6)
  Top 0.254: D10:C34.2 D10:R34.2 49.93,147.19 D10:R35.1 51.18,146.89 D10:R38.1
  Top 0.305: D10:R38.1 52.25,146.05 v59.31,146.05 | v75.82,148.59 76.45,149.22 112.65,149.22 113.92,150.5 135.51,150.5 v135.51,149.86
  Route2 0.305: v59.31,146.05 69.47,146.69 v75.82,148.59 | X3.A8 144.14,147.57 143.13,148.59 143.13,150.5 142.49,151.13 136.78,151.13 v135.51,149.86
OP11
  Top 0.254: D11:C34.2 D11:R34.2 94.38,146.56 D11:R35.1 95.63,146.26 D11:R38.1
  Top 0.305: D11:R38.1 96.27,145.54 96.14,145.41 134.24,145.41 136.14,147.32 X3.C8
OP12  (via drill 0.5)
  Top 0.305: D12:C34.2 D12:R34.2 94.38,136.4 D12:R35.1 95.63,136.09 D12:R38.1 98.88,135.46 v103.76,139.7 | v106.93,139.7 110.11,142.88 134.24,142.88 v134.87,142.24
  Route2 0.305: v134.87,142.24 136.14,143.51 142.49,143.51 142.75,143.26 142.75,141.1 X3.A5
  BOTTOM 0.305: v103.76,139.7 v106.93,139.7
OP13
  Top 0.305: D13:C34.2 D13:R34.2 47.39,135.13 D13:R35.1 48.64,134.83 D13:R38.1 52.12,134.19 59.31,127 97.41,127 108.84,138.43 133.6,138.43 134.87,139.7 X3.C5
OP14  (via drill 0.6)
  Top 0.254: D15:C34.2 D15:R34.2 47.39,122.43 D15:R35.1 48.64,122.13 D15:R38.1
  Top 0.305: D15:R38.1 60.15,121.49 v60.32,121.54 | v72.01,122.56 99.31,122.56 110.11,133.35 142.88,133.35 X3.A2
  Route2 0.305: v60.32,121.54 70.1,121.28 v72.01,122.56
OP15
  Top 0.254: D14:C34.2 D14:R34.2 94.38,121.16 D14:R35.1 95.63,120.86 D14:R38.1
  Top 0.305: D14:R38.1 99.52,120.22 111.38,132.08 X3.C2
OP16  (via drill 0.6)
  Top 0.254: D16:C34.2 D16:R34.2 47.39,105.92 D16:R35.1 48.64,105.61 D16:R38.1
  Top 0.305: D16:R38.1 51.05,106.05 96.39,106.05 106.93,96.01 106.93,80.64 120.27,67.94 132.33,67.94 v132.97,68.58
  Route2 0.254: 143.13,68.58 143.13,68.33
  Route2 0.305: v132.97,68.58 143.13,68.58 | 143.13,68.33 X4.A23
OP17  (via drill 0.6)
  Top 0.254: D17:C34.2 D17:R34.2 83.58,103 D17:R35.1 84.84,102.69 D17:R38.1
  Top 0.305: D17:R38.1 86.15,102.06 86.61,101.6 86.61,98.42 v87.88,97.16 | v91.06,94.61 91.69,95.25 99.31,95.25 101.85,92.71 101.85,81.28 117.73,65.41 137.16,65.41 X4.C23
  Route3 0.305: v87.88,97.16 89.15,95.89 v91.06,94.61
OP18
  Top 0.254: D18:C34.2 D18:R34.2 47.39,94.74 D18:R35.1 48.64,94.44 D18:R38.1
  Top 0.305: D18:R38.1 60.12,93.81 60.58,93.34 96.77,93.34 100.58,89.53 100.58,81.28 118.36,63.5 129.79,63.5 130.43,64.14 135.51,64.14 136.14,63.5 142.49,63.5 142.88,63.25 142.88,60.71 143.51,60.33 X4.A20
OP19  (via drill 0.6)
  Top 0.254: D19:C34.2 D19:R34.2 83.58,91.57 D19:R35.1 84.84,91.26 D19:R38.1
  Top 0.305: D19:R38.1 87.43,90.63 88.52,89.53 88.52,83.82 v89.15,83.19 | v96.14,83.19 97.41,81.92 97.41,80.01 115.82,61.59 129.79,61.59 131.06,60.33 138.43,60.33 X4.C20
  Route3 0.305: v89.15,83.19 v96.14,83.19
OP20
  Top 0.254: D20:C34.2 D20:R34.2 48.66,79.25 D20:R35.1 49.91,78.94 D20:R38.1
  Top 0.305: D20:R38.1 51.26,78.31 54.86,80.64 93.6,80.64 114.55,59.69 127.25,59.69 129.16,57.78 135.51,57.78 137.41,55.88 139.83,55.88 140.33,55.37 140.33,53.59 140.59,53.34 143.13,53.34 143.76,52.7 143.76,52.45 X4.A17
OP21
  Top 0.254: D21:C34.2 D21:R34.2 90.57,76.71 D21:R35.1 91.82,76.41 D21:R38.1
  Top 0.305: D21:R38.1 93.39,75.77 96.14,73.03 96.14,69.85 97.41,68.58 101.22,68.58 115.82,53.98 137.16,53.98 X4.C17
OP22
  Top 0.254: D22:C34.2 D22:R34.2 47.39,67.82 D22:R35.1 48.64,67.52 D22:R38.1
  Top 0.305: D22:R38.1 50.21,66.88 53.59,63.5 66.29,63.5 69.47,66.67 99.31,66.67 113.28,52.7 134.87,52.7 137.41,50.16 137.41,48.9 138.05,48.26 139.7,48.26 140.33,47.62 140.33,45.97 140.59,45.72 143.13,45.72 143.76,45.09 143.76,44.83 X4.A14
OP23
  Top 0.254: D23:C34.2 D23:R34.2 94.38,65.28 D23:R35.1 95.63,64.97 D23:R38.1
  Top 0.305: D23:R38.1 97.2,64.34 98.04,63.5 98.04,59.69 99.95,57.78 104.39,57.78 115.82,46.35 137.16,46.35 X4.C14
OP24
  Top 0.254: D24:C34.2 D24:R34.2 47.39,52.58 D24:R35.1 48.64,52.28 D24:R38.1
  Top 0.305: D24:R38.1 59.52,51.64 61.21,53.34 104.39,53.34 114.55,44.45 117.09,42.55 135.51,42.55 137.41,40.64 139.32,40.64 140.33,40.01 140.33,38.48 140.59,38.1 143.13,38.1 X4.A11
OP25
  Top 0.254: D25:C34.2 D25:R34.2 94.38,50.55 D25:R35.1 95.63,50.24 D25:R38.1
  Top 0.305: D25:R38.1 98.04,49.53 99.95,42.55 111.38,42.55 120.27,36.83 X4.C11
OP26
  Top 0.254: D26:C34.2 D26:R34.2 47.39,41.15 D26:R35.1 48.64,40.85 D26:R38.1
  Top 0.305: D26:R38.1 63.96,40.21 64.39,40.64 110.11,40.64 119.63,34.92 135.51,34.92 137.41,33.02 139.57,33.02 140.33,32.51 140.33,30.86 141.35,30.48 143.13,30.48 X4.A8
OP27  (via drill 0.6)
  Top 0.254: D27:C34.2 D27:R34.2 94.38,39.12 D27:R35.1 95.63,38.81 D27:R38.1
  Top 0.305: D27:R38.1 98.04,38.1 v98.68,33.02 | v98.68,29.84 100.58,31.11 136.78,31.11 X4.C8
  Route3 0.305: v98.68,33.02 v98.68,29.84
OP28
  Top 0.254: D28:C34.2 D28:R34.2 48.02,27.81 D28:R35.1 49.28,27.51 D28:R38.1
  Top 0.305: D28:R38.1 51.26,26.88 55.5,29.84 68.83,29.84 70.1,28.57 84.07,28.57 85.98,27.3 136.14,27.3 138.05,25.4 139.7,25.4 140.33,24.89 140.33,23.24 140.72,22.86 143.13,22.86 X4.A5
OP29
  Top 0.254: D29:C34.2 D29:R34.2 94.38,24.89 D29:R35.1 95.63,24.59 D29:R38.1
  Top 0.305: D29:R38.1 98.68,23.5 99.31,22.86 138.05,22.86 X4.C5
OP30  (via drill 0.6)
  Top 0.254: D30:C34.2 D30:R34.2 48.02,16.38 D30:R35.1 49.28,16.08 D30:R38.1
  Top 0.305: D30:R38.1 51.48,15.45 v51.69,15.24 | v56.77,14.61 57.4,15.24 99.31,15.24 103.76,20.95 132.97,20.95 136.78,17.78 139.45,17.78 140.33,17.27 140.33,15.75 140.84,15.24 143.13,15.24 X4.A2
  Route2 0.305: v51.69,15.24 56.13,15.24 v56.77,14.61
OP31
  Top 0.254: D31:C34.2 D31:R34.2 94.38,13.21 D31:R35.1 95.63,12.9 D31:R38.1
  Top 0.305: D31:R38.1 99.31,12.7 104.39,19.68 132.97,19.68 X4.C2
POWEN  (via drill 0.6)
  Top 0.406: R6.2 132.32,128.28 v131.06,129.54 | v129.16,104.78 R26.2
  Route2 0.305: v142.75,103.5 129.79,103.5 v129.16,104.78
  Route3 0.305: 142.88,76.2 142.75,99.57 v142.75,103.5
  Route3 0.406: v131.06,129.54 130.99,113.89 129.18,112.5 v129.16,104.78 | X4.A26 142.88,76.2
POWENP  (via drill 0.6)
  Top 0.305: R23.2 118.39,105.45 | R23.2 118.38,105.41 119.63,105.41 120.27,104.78 R26.1 R50.1 122.79,102.89 123.44,102.87 v126.62,102.87 | U21.1 R23.2 | v125.98,93.34 128.52,93.34 U22.1
  Route3 0.305: v126.62,102.87 126.62,94.61 125.98,93.98 v125.98,93.34
SCL1  (via drill 0.5, 0.6)
  Top 0.254: U5.8 R51.1 117.08,204.47 v112.65,204.47 | U2.2 62.86,189.1 62.99,189.23 v62.99,190.5
  Top 0.305: U1.2 17.91,190.37 18.8,189.99 v19.3,187.32 | U6.2 17.91,138.94 19.3,139.7 v19.3,141.6 | U7.2 64.26,141.48 64.39,141.6 v64.39,143.51
  Route2 0.254: v112.65,204.47 110.74,201.29 73.28,201.29 70.74,198.75 v62.36,198.75 | v19.3,187.32 19.94,186.69 23.75,186.69 25.65,188.59 50.42,188.59 51.69,189.87 57.4,189.87 58.04,190.5 v62.99,190.5
  Route3 0.254: v62.99,190.5 v62.36,198.75
  Route3 0.305: v19.3,187.32 v19.3,141.6 | v64.39,143.51 64.39,186.06 63.12,187.32 63.12,190.37 v62.99,190.5
SCL2  (via drill 0.6)
  Top 0.254: U13.8 v120.27,82.55 119.63,81.28 U4.5
  Top 0.305: v108.84,82.55 110.11,85.08 R48.1 | v61.21,76.83 61.21,75.56 61.09,75.44 U10.2 | U9.2 18.54,77.98 18.67,78.11 v18.67,80.01 | v17.4,31.11 17.4,29.21 17.27,29.08 U11.2 | U12.2 62.36,23.37 62.48,23.5 62.48,24.13 v59.94,26.67
  Route2 0.254: v120.27,82.55 v108.84,82.55
  Route2 0.305: v108.84,82.55 107.57,82.55 105.66,80.64 61.21,80.64 | v18.67,80.01 18.67,80.64 20.57,82.55 59.31,82.55 61.21,80.64 | v61.21,79.38 61.21,80.64
  Route3 0.305: v61.21,79.38 v61.21,76.83 60.58,76.2 60.58,73.03 61.21,72.39 61.21,28.57 59.94,27.3 v59.94,26.67 | v18.67,80.01 18.67,32.38 v17.4,31.11
SCL_EXT1
  Top 0.254: X7.3 U5.5
  Top 0.305: X3.C29 137.41,202.56 R20.1 X7.3
SCL_EXT2  (via drill 0.6)
  Top 0.254: 132.33,83.82 X5.3 | R37.1 134.87,85.09
  Top 0.305: U13.5 125.35,83.82 v125.98,83.82 X5.3 133.6,83.82 134.87,85.09 | X4.C29 137.41,83.82 137.41,85.09 R37.1 | U20.2 109.14,98.75 v109.47,95.25
  Route2 0.305: v110.74,90.17 118.36,88.9 120.27,88.27 v125.98,88.27
  Route3 0.305: v109.47,95.25 v110.74,90.17 | v125.98,83.82 v125.98,88.27
SDA1  (via drill 0.5, 0.6)
  Top 0.254: U5.1 R49.1 113.92,201.29 v113.28,201.29 | U2.3 v64.01,188.59
  Top 0.305: U1.3 17.65,189.87 18.03,189.48 v18.03,186.06 | U6.3 18.03,138.43 18.67,137.79 18.67,137.16 18.03,136.53 v18.03,135.89 | U7.3 65.02,140.97 65.66,141.6 v65.66,144.15
  Route2 0.254: v113.28,201.29 111.38,199.39 94.23,199.39 93.6,198.75 65.02,198.12 64.64,198.12 v64.01,196.85 | v18.03,186.06 25.02,186.06 26.29,187.96 52.96,187.96 53.59,188.59 v64.01,188.59
  Route3 0.254: v64.01,196.85 v64.01,188.59
  Route3 0.305: v18.03,186.06 v18.03,135.89 | v65.66,144.15 65.66,186.94 v64.01,188.59
SDA2  (via drill 0.6)
  Top 0.305: U13.1 v120.02,79.88 U4.4 R47.1 | v61.85,73.66 61.85,74.3 61.21,74.93 U10.3 | U9.3 19.3,77.47 19.94,78.11 19.94,80.01 v21.21,81.28 | U11.3 18.16,28.57 18.42,28.83 18.42,32.13 18.54,32.26 19.81,32.26 v19.94,32.38 | U12.3 63.12,22.86 63.75,23.5 63.75,24.77 63.44,25.08 63.12,25.4 v61.85,26.67
  Route2 0.254: v120.02,79.88 109.47,80.01
  Route2 0.305: 109.47,80.01 63.75,80.01 v62.48,78.74 61.85,78.11 59.94,78.11 59.94,78.74 58.67,80.01 58.67,80.64 57.4,81.92 51.69,81.92 51.05,81.28 v21.21,81.28
  Route3 0.305: v62.48,78.74 62.48,74.3 v61.85,73.66 v61.85,26.67 | v19.94,32.38 19.94,80.01 v21.21,81.28
SDA_EXT1
  Top 0.254: X7.2 U5.4 | 142.49,199.39 R14.1 135.51,200.66 134.24,200.66
  Top 0.305: X3.A29 142.49,199.39 | 134.24,200.66 X7.2
SDA_EXT2  (via drill 0.6)
  Top 0.305: X4.A29 143.13,81.28 137.41,81.28 136.78,80.01 R34.1 134.24,80.01 X5.2 127.25,81.28 126.62,80.64 v124.71,80.64 123.39,80.64 U13.4 | U20.1 108.46,99.57 107.32,99.06 v106.81,99.06
  Route2 0.305: v108.71,88.27 122.81,87 v124.71,87
  Route3 0.305: v106.81,99.06 v108.71,88.27 | v124.71,87 v124.71,80.64
TALERT  (via drill 0.6)
  Top 0.254: X4.C26 139.06,75.18 | 136.16,76.83 R12.2
  Top 0.305: U20.3 109.8,98.22 109.98,98.04 111.76,98.04 v112.01,97.79 | v137.41,78.74 136.14,77.47 R12.2 | 139.06,75.18 137.41,76.83 136.16,76.83
  Route2 0.305: v112.01,97.79 117.09,97.79 119,99.69 127.89,99.69 128.52,100.33 131.7,100.33 132.33,99.69 v136.14,99.69
  Route3 0.254: v136.14,99.69 136.14,79.38 136.78,79.38 v137.41,78.74
V1_8A
  Top 0.305: X3.C27 136.79,195.58 R58.1
V1_8B  (via drill 0.6)
  Top 0.305: v121.54,76.2 R38.1
  Route2 0.305: X4.C27 123.44,77.47 122.17,76.2 v121.54,76.2
V3.3  (via drill 0.6)
  Top 0.254: C7.1 U20.8 v108.46,101.98 | R37.2 135.51,82.55 R34.2 | U13.3 122.81,79.38 C19.1 | R46.2 X7.1 | R14.2 132.33,199.39 131.7,198.12 X7.1 | v134.87,203.84 R20.2 | U5.3 119.89,199.9 C20.1 | X7.1 122.81,198.12 122.17,198.75 C20.1 | C20.1 120.25,198.75 119.63,198.75 119,198.12 R33.2
  Top 0.305: R37.2 135.52,83.81 | v137.41,82.55 135.51,82.55
  Top 0.406: C19.1 X5.1 132.97,78.74 134.24,77.47 134.24,76.2 134.87,75.56 R12.1 136.14,74.3 136.78,73.66 142.49,73.66 142.88,73.91 142.88,76.2 X4.A27
  Route2 0.254: v108.46,101.98 110.16,101.98 110.67,102.49 115.98,102.49 117.07,101.4 136.14,101.6 v137.41,101.6 | X5.1 134.24,82.55 | X3.A27 143.13,196.85 133.6,196.85 132.97,198.12 X7.1
  Route2 0.305: 134.24,82.55 v137.41,82.55
  Route3 0.254: v137.41,101.6 v137.41,82.55 | X7.1 132.97,199.39 132.97,202.56 v134.87,203.84
  Route3 0.406: X7.1 129.79,134.62 136.14,127.64 136.14,117.47 134.24,114.94 134.24,114.3 133.6,113.67 133.6,100.97 131.7,100.97 128.52,97.79 128.52,92.71 127.25,91.44 127.25,88.9 128.52,87.63 128.52,81.28 X5.1
V5  (via drill 0.4, 0.6)
  Top 0.254: v41.97,208.47 D0:U1.3 | v88.96,206.19 88.96,204.48 D1:U1.3 | v41.97,197.04 D2:U1.3 | v88.96,194.25 88.96,192.54 D3:U1.3 | v41.97,181.8 D4:U1.3 | v88.96,179.26 D5:U1.3 | v41.97,169.1 D6:U1.3 | v88.96,167.83 D7:U1.3 | v41.97,156.4 D8:U1.3 | v88.96,155.13 D9:U1.3 | v44.51,143.06 44.51,141.36 D10:U1.3 | v88.96,142.43 D11:U1.3 | v41.97,131 D13:U1.3 | v88.96,132.27 D12:U1.3 | v41.97,118.3 D15:U1.3 | v88.96,117.03 D14:U1.3 | v41.97,101.79 D16:U1.3 | v78.17,98.87 78.17,97.17 D17:U1.3 | v41.97,90.61 41.97,88.91 D18:U1.3 | v78.17,87.44 78.17,85.74 D19:U1.3 | v43.24,75.12 43.24,73.42 D20:U1.3 | v85.15,72.58 D21:U1.3 | v41.97,63.69 D22:U1.3 | v88.96,61.15 D23:U1.3 | v41.97,48.45 D24:U1.3 | v88.96,46.42 88.96,44.72 D25:U1.3 | v41.97,37.02 D26:U1.3 | v88.96,34.99 88.96,33.29 D27:U1.3 | v42.61,23.69 42.61,21.98 D28:U1.3 | v88.96,20.77 88.96,19.06 D29:U1.3 | v42.61,12.26 42.61,10.55 D30:U1.3 | v88.96,9.08 D31:U1.3 | LED1.A v105.66,111.76
  Top 0.305: C24.1 117.93,191.77 U19.5 | R30.2 T5V.TP | U17.5 C25.1
  Top 0.406: v131.06,74.93 C25.1 | C24.1 115.82,191.75 v115.82,189.87
  Top 0.813: U21.3 T5V.TP | C18.+ v101.35,111.12
  Route2 0.254: v105.66,111.76 105.68,110.03
  Route2 0.406: v89.15,111.24 89.18,111.22 91.7,111.22 | v77.73,111.37 v77.72,111.37 77.09,111.37 | v117.73,74.93 v131.06,74.93 | v115.82,189.87 96.77,189.87 96.14,189.23 v88.96,189.23
  Route2 0.813: T5V.TP 112.78,110.24 110.45,111.76 105.68,110.03 v101.35,111.12 v89.15,111.24 v77.73,111.37 77.09,111.37 v41.53,111.76
  Route3 0.406: v41.97,118.3 v41.97,131 v44.51,143.06 v41.97,156.4 v41.97,169.1 v41.97,181.8 v41.97,197.04 v41.97,208.47 | v88.96,206.19 v88.96,194.25 v88.96,189.23 v88.96,179.26 v88.96,167.83 v88.96,155.13 v88.96,142.43 v88.96,132.27 v88.96,117.03 89.15,116.85 v89.15,111.24 | v77.73,111.37 77.73,99.31 v78.17,98.87 v78.17,87.44 78.23,87.38 78.23,82.68 84.71,76.2 84.71,74.3 84.63,74.22 84.63,72.89 84.94,72.58 v85.15,72.58 85.34,72.39 85.34,62.87 87.06,61.78 v88.96,61.15 v88.96,46.42 v88.96,34.99 v88.96,20.77 v88.96,9.08 | T5V.TP 119.63,109.86 119.63,83.82 117.09,81.28 117.73,80.64 v117.73,74.93 | v41.97,101.79 v41.97,90.61 v43.24,75.12 v41.97,63.69 v41.97,48.45 v41.97,37.02 41.97,24.32 v42.61,23.69 v42.61,12.26
  Route3 0.61: v41.97,118.3 v41.53,111.76 41.53,102.87 v41.97,101.79
  BOTTOM 0.254: D0:R39.2 42.93,207.52 v41.97,208.47 | D1:R39.2 89.92,205.23 v88.96,206.19 | D2:R39.2 42.93,196.09 v41.97,197.04 | D3:R39.2 89.92,193.29 v88.96,194.25 | D4:R39.2 42.93,180.85 v41.97,181.8 | D5:R39.2 89.92,178.31 v88.96,179.26 | D6:R39.2 42.93,168.15 v41.97,169.1 | D7:R39.2 89.92,166.88 v88.96,167.83 | D8:R39.2 42.93,155.45 v41.97,156.4 | D9:R39.2 89.92,154.18 v88.96,155.13 | D10:R39.2 45.47,142.11 v44.51,143.06 | D11:R39.2 89.92,141.48 v88.96,142.43 | D13:R39.2 42.93,130.05 v41.97,131 | D12:R39.2 89.92,131.32 v88.96,132.27 | D15:R39.2 42.93,117.35 v41.97,118.3 | D14:R39.2 89.92,116.08 v88.96,117.03 | D16:R39.2 42.93,100.84 v41.97,101.79 | D17:R39.2 79.12,97.92 v78.17,98.87 | D18:R39.2 42.93,89.66 v41.97,90.61 | D19:R39.2 79.12,86.49 v78.17,87.44 | D20:R39.2 44.2,74.17 v43.24,75.12 | D21:R39.2 86.11,71.63 v85.15,72.58 | D22:R39.2 42.93,62.74 v41.97,63.69 | D23:R39.2 89.92,60.2 v88.96,61.15 | D24:R39.2 42.93,47.5 v41.97,48.45 | D25:R39.2 89.92,45.47 v88.96,46.42 | D26:R39.2 42.93,36.07 v41.97,37.02 | D27:R39.2 89.92,34.04 v88.96,34.99 | D28:R39.2 43.56,22.73 v42.61,23.69 | D29:R39.2 89.92,19.81 v88.96,20.77 | D30:R39.2 43.56,11.3 v42.61,12.26 | D31:R39.2 89.92,8.13 v88.96,9.08
  BOTTOM 0.406: D0:C2.2 D0:C1.2 39.75,210.06 40.39,209.42 v41.97,208.47 | D1:C2.2 D1:C1.2 86.74,207.77 87.38,207.14 v88.96,206.19 | D2:C2.2 D2:C1.2 39.75,198.63 40.39,197.99 v41.97,197.04 | D3:C2.2 D3:C1.2 86.74,195.83 87.38,195.2 v88.96,194.25 | D4:C2.2 D4:C1.2 39.75,183.39 40.39,182.75 v41.97,181.8 | D5:C2.2 D5:C1.2 86.74,180.85 87.38,180.21 v88.96,179.26 | D6:C2.2 D6:C1.2 39.75,170.69 40.39,170.05 v41.97,169.1 | D7:C2.2 D7:C1.2 86.74,169.42 87.38,168.78 v88.96,167.83 | D8:C2.2 D8:C1.2 39.75,157.99 40.39,157.35 v41.97,156.4 | D9:C2.2 D9:C1.2 86.74,156.72 87.38,156.08 v88.96,155.13 | D10:C2.2 D10:C1.2 42.29,144.65 42.93,144.02 v44.51,143.06 | D11:C2.2 D11:C1.2 86.74,144.02 87.38,143.38 v88.96,142.43 | D13:C2.2 D13:C1.2 39.75,132.59 40.39,131.95 v41.97,131 | D12:C2.2 D12:C1.2 86.74,133.86 87.38,133.22 v88.96,132.27 | D15:C2.2 D15:C1.2 39.75,119.89 40.39,119.25 v41.97,118.3 | D14:C2.2 D14:C1.2 86.74,118.62 87.38,117.98 v88.96,117.03 | D16:C2.2 D16:C1.2 39.75,103.38 40.39,102.74 v41.97,101.79 | D17:C2.2 D17:C1.2 75.95,100.46 76.58,99.82 v78.17,98.87 | D18:C2.2 D18:C1.2 39.75,92.2 40.39,91.57 v41.97,90.61 | D19:C2.2 D19:C1.2 75.95,89.03 76.58,88.39 v78.17,87.44 | D20:C2.2 D20:C1.2 41.02,76.71 41.66,76.07 v43.24,75.12 | D21:C2.2 D21:C1.2 82.93,74.17 83.57,73.53 v85.15,72.58 | D22:C2.2 D22:C1.2 39.75,65.28 40.39,64.64 v41.97,63.69 | D23:C2.2 D23:C1.2 86.74,62.74 87.38,62.1 v88.96,61.15 | D24:C2.2 D24:C1.2 39.75,50.04 40.39,49.4 v41.97,48.45 | D25:C2.2 D25:C1.2 86.74,48.01 87.38,47.37 v88.96,46.42 | D26:C2.2 D26:C1.2 39.75,38.61 40.39,37.97 v41.97,37.02 | D27:C2.2 D27:C1.2 86.74,36.58 87.38,35.94 v88.96,34.99
  BOTTOM 0.406: D28:C2.2 D28:C1.2 40.39,25.27 41.02,24.64 v42.61,23.69 | D29:C2.2 D29:C1.2 86.74,22.35 87.38,21.72 v88.96,20.77 | D30:C2.2 D30:C1.2 40.39,13.84 41.02,13.21 v42.61,12.26 | D31:C2.2 D31:C1.2 86.74,10.67 87.38,10.03 v88.96,9.08
V5D  (via drill 0.5, 0.6)
  Top 0.254: U5.7 119.38,204.98 C22.1 118.36,206.38 R51.2 v114.55,205.74 | R33.1 R49.2 v114.55,200.03 | U13.7 122.17,84.84 121.54,84.84 119.89,84.84 R13.2 | U3.3 115.44,10.41 117.65,10.98 | 117.65,10.98 v118.87,12.06 | 117.65,10.98 117.98,11.31 C5.1 118.24,10.18 C8.1 120.28,9.53 121.54,9.53 122.19,8.88 R16.2
  Top 0.305: R4.2 v15.49,192.41 | U22.3 132.19,96.39 R2.2 | C6.1 U4.3 116.15,80.34 116.46,80.64 | 121.52,86.36 C23.1 121.54,84.84 | R48.2 111.39,85.74 112.01,86.36 | 116.46,86.36 v117.73,86.36 | v16.76,142.88 R21.2 | R28.2 v15.49,83.19 | R24.2 61.85,143.51 v61.85,144.78 | v16.76,32.38 14.87,32.38 R40.2 | R43.2 59.29,28.59 v59.31,28.57
  Top 0.406: U4.3 115.19,79.38 R47.2 | v117.73,86.36 121.52,86.36 | 112.01,86.36 116.46,86.36 116.46,80.64 | R35.2 58.02,78.75 v58.04,78.74 | v61.21,191.77 59.93,191.77 R10.2
  Top 0.813: U22.3 T5D.TP | C16.+ v117.73,93.98
  Route2 0.305: v118.87,12.06 108.84,12.06 108.2,11.43 v103.12,11.43
  Route2 0.406: v56.77,107.95 56.77,109.22 | v61.85,107.95 61.85,109.22 | v101.85,197.49 112.01,197.49 v114.55,200.03
  Route2 0.813: T5D.TP 117.73,96.52 | 117.73,96.52 v101.98,96.96 102.28,97.16 98.68,97.16 v96.77,98.42 | v117.73,93.98 117.73,96.52 | v96.77,109.22 61.85,109.22 56.77,109.22 v16.76,109.22
  Route3 0.254: v114.55,200.03 v114.55,205.74
  Route3 0.305: v15.49,192.41 16.13,192.41 16.76,191.77 v16.76,142.88 v16.76,109.22 16.76,83.19 | 16.76,83.19 v16.76,32.38 | v15.49,83.19 16.76,83.19 | v59.31,28.57 59.31,78.11 v58.04,78.74
  Route3 0.406: v117.73,93.98 v117.73,86.36 | v61.85,107.95 v61.85,144.78 61.85,145.41 60.58,146.69 60.58,185.42 61.85,186.69 61.85,191.13 v61.21,191.77 | v58.04,78.74 56.77,80.01 v56.77,107.95 | v103.12,11.43 104.39,15.24 108.84,17.14 112.65,17.78 112.65,73.03 104.39,81.28 104.39,94.61 102.48,96.53 v101.98,96.96 | v96.77,109.22 96.77,109.86 99.31,112.39 99.31,194.94 v101.85,197.49
  Route3 0.813: v96.77,98.42 v96.77,109.22
V5E1
  Top 0.406: X4.A32 143.76,90.55 143.76,90.81 143.13,91.44 139.95,91.44 139.06,90.55 X4.C32 V5E1.TP
V5E2
  Top 0.406: V5E2.TP X3.C32 139.06,207.9 139.95,207.01 143.13,207.01 143.76,207.65 143.76,207.9 X3.A32
VBIAS  (via drill 0.4, 0.6)
  Top 0.254: D0:R36.2 25.78,209.42 25.15,210.06 v25.15,210.69 | D1:R36.2 72.77,207.14 72.14,207.77 v72.14,208.41 | D2:R36.2 25.78,197.99 25.15,198.63 v25.15,199.26 | D3:R36.2 72.77,195.2 72.14,195.83 v72.14,196.47 | D4:R36.2 25.78,182.75 25.15,183.39 v25.15,184.02 | D5:R36.2 72.77,180.21 72.14,180.85 v72.14,181.48 | D6:R36.2 25.78,170.05 25.15,170.69 v25.15,171.32 | D7:R36.2 72.77,168.78 72.14,169.42 v72.14,170.05 | D8:R36.2 25.78,157.35 25.15,157.99 v25.15,158.62 | D9:R36.2 72.77,156.08 72.14,156.72 v72.14,157.35 | D10:R36.2 28.32,144.02 27.69,144.65 v27.69,145.29 | D11:R36.2 72.77,143.38 72.14,144.02 v72.14,144.65 | D13:R36.2 25.78,131.95 25.15,132.59 v25.15,133.22 | D12:R36.2 72.77,133.22 72.14,133.86 v72.14,134.49 | D15:R36.2 25.78,119.25 25.15,119.89 v25.15,120.52 | D14:R36.2 72.77,117.98 72.14,118.62 v72.14,119.25 | D16:R36.2 25.78,102.74 25.15,103.38 v25.15,104.01 | D17:R36.2 61.98,99.82 61.34,100.46 v61.34,101.09 | D18:R36.2 25.78,91.57 25.15,92.2 v25.15,92.84 | D19:R36.2 61.98,88.39 61.34,89.03 v61.34,89.66 | D20:R36.2 27.05,76.07 26.42,76.71 v26.42,77.34 | D21:R36.2 68.96,73.53 68.33,74.17 v68.33,74.8 | D22:R36.2 25.78,64.64 25.15,65.28 v25.15,65.91 | D23:R36.2 72.77,62.1 72.14,62.74 v72.14,63.37 | D24:R36.2 25.78,49.4 25.15,50.04 v25.15,50.67 | D25:R36.2 72.77,47.37 72.14,48.01 v72.14,48.64 | D26:R36.2 25.78,37.97 25.15,38.61 v25.15,39.24 | D27:R36.2 72.77,35.94 72.14,36.58 v72.14,37.21 | D28:R36.2 26.42,24.64 25.78,25.27 v25.78,25.91 | D29:R36.2 72.77,21.72 72.14,22.35 v72.14,22.99 | D30:R36.2 26.42,13.21 25.78,13.84 v25.78,14.48 | D31:R36.2 72.77,10.03 72.14,10.67 v72.14,11.3
  Top 0.254: U3.8 112.51,11.56 | 110.43,12.7 R9.1 | 107.88,13.02 VB.TP
  Top 0.305: 112.51,11.56 111.38,12.7 110.43,12.7 | R9.1 107.88,13.02
  Route2 0.305: VB.TP 105.66,13.34 101.85,16.51 v72.01,13.97 68.83,13.97 65.66,17.14 26.29,17.14 25.65,16.51 25.65,14.61 v25.78,14.48 | v63.75,119.38 69.47,119.38
  Route2 0.406: 69.47,119.38 72.01,119.38 v72.14,119.25
  Route3 0.305: v25.15,199.26 23.75,199.39 | 23.75,199.39 23.75,210.82 v25.15,210.69 | v25.78,14.48 26.92,15.24 26.82,25.91 | 26.82,25.91 26.68,39.25 | 26.68,39.25 26.56,50.68 | 26.56,50.68 27.13,66.03 | 27.13,66.03 27.56,77.47 | 27.56,77.47 26.29,93.22 | 26.29,93.22 26.29,104.14 | 26.29,104.14 26.29,120.65 | 26.29,120.65 26.29,133.35 | 26.29,133.35 26.29,145.41 | 26.29,145.41 23.75,151.76 23.75,158.75 | 23.75,158.75 23.75,171.45 | 23.75,171.45 23.88,183.13 25.15,184.15 | 25.15,184.15 25.15,184.91 23.75,186.06 23.75,199.39 | v27.69,145.29 26.42,145.29 26.29,145.41 | v25.15,158.62 23.88,158.62 23.75,158.75 | v25.15,171.32 23.88,171.32 23.75,171.45 | v25.15,133.22 25.78,133.22 26.29,133.35 | v25.15,120.52 26.42,120.52 26.29,120.65 | 25.15,184.15 v25.15,184.02 | 26.29,104.14 25.65,104.14 v25.15,104.01 | v25.15,92.84 26.29,93.22 | 27.56,77.47 v26.42,77.34 | v25.78,25.91 26.81,25.91 26.82,25.91 | v25.15,39.24 26.67,39.24 26.68,39.25 | v25.15,50.67 26.56,50.67 26.56,50.68 | v25.15,65.91 27.01,65.91 27.13,66.03 | v72.14,11.3 72.01,13.08 v72.01,13.97 73.28,15.24 73.28,21.84 v72.14,22.99 72.14,28.07 74.55,30.48 74.55,34.8 v72.14,37.21 72.14,38.86 73.28,40.01 73.28,47.5 v72.14,48.64 72.14,54.1 73.91,55.88 73.91,61.59 v72.14,63.37 72.14,70.48 68.33,74.3 v68.33,74.8 68.33,82.68 v61.34,89.66 61.34,90.3 62.48,91.44 62.48,99.95 v61.34,101.09 61.34,103.63 63.12,105.41 63.12,118.75 v63.75,119.38 | 73.28,120.65 73.28,133.35 v72.14,134.49 72.14,135.13 72.01,135.25 72.01,135.89 73.91,137.79 73.91,142.88 v72.14,144.65 72.14,147.19 72.64,147.96 74.55,149.86 74.55,154.94 v72.14,157.35 72.14,159.51 73.28,160.66 73.28,168.58 D7:R36.2 72.9,168.78 72.14,169.54 v72.14,170.05 72.14,171.32 72.01,171.45 72.01,173.99 73.91,175.9 73.91,179.2 72.14,180.97 v72.14,181.48 72.14,182.75 72.01,182.88 72.01,187.96 73.91,189.87 73.91,194.69 v72.14,196.47 72.14,200.79 73.28,201.93 73.28,207.26 v72.14,208.41
  Route3 0.406: 73.28,120.65 73.28,120.4 v72.14,119.25
VCOMA  (via drill 0.4, 0.6)
  Top 0.305: U19.1 120.02,191.77 119.38,191.77 118.87,192.28 118.87,192.79 118.59,193.06 U19.4 116.43,193.06 v115.82,193.68
  Route2 0.305: v115.82,193.68 v105.03,193.68 | v105.03,187.96 82.17,187.96 v81.53,188.59 | v81.66,164.66 81.66,163.32 80.9,162.56 v34.54,161.93
  Route3 0.305: v105.03,193.68 v105.03,187.96 | v81.66,113.86 v81.66,129.09 v81.66,139.26 v81.66,151.96 v81.66,164.66 v81.66,176.09 81.66,188.47 v81.53,188.59 81.53,190.94 v81.66,191.07 v81.66,203.01 | v34.67,205.3 v34.67,193.87 v34.67,178.62 v34.67,165.93 34.54,165.8 v34.54,161.93 v34.67,153.23 37.08,151.13 v37.21,139.89 v34.67,127.83 v34.67,115.13
  BOTTOM 0.254: D0:R1.1 35.94,206.56 v34.67,205.3 | D2:R1.1 35.94,195.14 v34.67,193.87 | D4:R1.1 35.94,179.9 v34.67,178.62 | D6:R1.1 35.94,167.2 v34.67,165.93 | D8:R1.1 35.94,154.5 v34.67,153.23 | D10:R1.1 38.48,141.16 v37.21,139.89 | D13:R1.1 35.94,129.09 v34.67,127.83 | D15:R1.1 35.94,116.39 v34.67,115.13 | D14:R1.1 82.93,115.13 v81.66,113.86 | D12:R1.1 82.93,130.37 v81.66,129.09 | D11:R1.1 82.93,140.53 v81.66,139.26 | D9:R1.1 82.93,153.23 v81.66,151.96 | D1:R1.1 82.93,204.28 v81.66,203.01 | D7:R1.1 82.93,165.93 v81.66,164.66 | D3:R1.1 82.93,192.34 v81.66,191.07 | D5:R1.1 82.93,177.36 v81.66,176.09
VCOMB  (via drill 0.4, 0.6)
  Top 0.305: U17.4 128.27,71.12 128.02,71.12 127.89,71.25 127.89,71.5 127.61,71.78 U17.1 126.85,72.8 v126.62,73.03
  Route2 0.305: v126.62,73.03 101.22,73.03 95.5,78.74 v77.72,78.74 | v34.54,55.88 69.47,55.88 70.1,55.24 v81.66,55.24
  Route3 0.305: 81.53,44.45 81.53,45.72 82.17,54.74 v81.66,55.24 v81.66,57.98 81.53,58.1 81.53,62.87 77.85,66.55 v77.85,69.41 77.72,69.53 v77.72,78.74 71.37,82.55 v70.87,84.26 v70.87,95.69 | v81.66,17.59 v81.66,5.91 | v35.31,9.08 v35.31,20.51 34.67,21.14 v34.67,33.85 v34.67,45.28 34.67,55.37 v34.54,55.88 34.67,56.39 v34.67,60.52 v35.94,71.94 v34.67,87.44 v34.67,98.61
  Route3 0.406: 81.53,44.45 v81.66,43.24 v81.66,31.81 v81.66,17.59
  BOTTOM 0.254: D30:R1.1 36.58,10.35 v35.31,9.08 | D17:R1.1 72.14,96.97 v70.87,95.69 | D19:R1.1 72.14,85.53 v70.87,84.26 | D21:R1.1 79.12,70.67 v77.85,69.41 | D23:R1.1 82.93,59.24 v81.66,57.98 | D25:R1.1 82.93,44.51 v81.66,43.24 | D27:R1.1 82.93,33.08 v81.66,31.81 | D29:R1.1 82.93,18.86 v81.66,17.59 | D26:R1.1 35.94,35.12 v34.67,33.85 | D28:R1.1 36.58,21.78 v35.31,20.51 | D24:R1.1 35.94,46.55 v34.67,45.28 | D22:R1.1 35.94,61.78 v34.67,60.52 | D20:R1.1 37.21,73.22 v35.94,71.94 | D16:R1.1 35.94,99.89 v34.67,98.61 | D18:R1.1 35.94,88.71 v34.67,87.44 | D31:R1.1 82.93,7.18 v81.66,5.91
VEE  (via drill 0.4, 0.6)
  Top 0.254: v42.93,209.42 42.29,209.42 41.97,209.74 41.97,210.81 D0:U1.6 | v89.92,207.14 89.28,207.14 88.96,207.45 D1:U1.6 | v42.93,197.99 42.29,197.99 41.97,198.31 41.97,199.38 D2:U1.6 | v89.92,195.2 89.28,195.2 88.96,195.52 88.96,196.58 D3:U1.6 | v42.93,182.75 42.29,182.75 41.97,183.07 41.97,184.14 D4:U1.6 | v89.92,180.21 89.28,180.21 88.96,180.53 88.96,181.6 D5:U1.6 | v42.93,170.05 42.29,170.05 41.97,170.37 41.97,171.44 D6:U1.6 | v89.92,168.78 89.28,168.78 88.96,169.1 88.96,170.17 D7:U1.6 | v42.93,157.35 42.29,157.35 41.97,157.67 41.97,158.74 D8:U1.6 | v89.92,156.08 89.28,156.08 88.96,156.4 88.96,157.47 D9:U1.6 | v45.47,144.02 44.83,144.02 44.51,144.34 44.51,145.4 D10:U1.6 | v89.92,143.38 89.28,143.38 88.96,143.7 88.96,144.77 D11:U1.6 | v42.93,131.95 42.29,131.95 41.97,132.27 41.97,133.34 D13:U1.6 | v89.92,133.22 89.28,133.22 88.96,133.54 88.96,134.61 D12:U1.6 | v42.93,119.25 42.29,119.25 41.97,119.57 41.97,120.64 D15:U1.6 | v89.92,117.98 89.28,117.98 88.96,118.3 88.96,119.37 D14:U1.6 | v42.93,102.74 42.29,102.74 41.97,103.06 41.97,104.13 D16:U1.6 | v79.12,99.82 78.49,99.82 78.17,100.14 78.17,101.21 D17:U1.6 | v42.93,91.57 42.29,91.57 41.97,91.89 D18:U1.6 | v79.12,88.39 78.49,88.39 78.17,88.71 78.17,89.78 D19:U1.6 | v44.2,76.07 43.56,76.07 43.24,76.39 43.24,77.46 D20:U1.6 | v86.11,73.53 85.47,73.53 85.15,73.85 85.15,74.92 D21:U1.6 | v42.93,64.64 42.29,64.64 41.97,64.96 41.97,66.03 D22:U1.6 | v89.92,62.1 89.28,62.1 88.96,62.42 88.96,63.49 D23:U1.6 | v42.93,49.4 42.29,49.4 41.97,49.72 41.97,50.79 D24:U1.6 | v89.92,47.37 89.28,47.37 88.96,47.69 88.96,48.76 D25:U1.6
  Top 0.254: v42.93,37.97 42.29,37.97 41.97,38.29 41.97,39.36 D26:U1.6 | v89.92,35.94 89.28,35.94 88.96,36.26 88.96,37.33 D27:U1.6 | v43.56,24.64 42.93,24.64 42.61,24.96 42.61,26.02 D28:U1.6 | v89.92,21.72 89.28,21.72 88.96,22.04 D29:U1.6 | v43.56,13.21 42.93,13.21 42.61,13.53 42.61,14.59 D30:U1.6 | v89.92,10.03 89.28,10.03 88.96,10.35 88.96,11.42 D31:U1.6
  Top 0.305: U14.12 121.77,121.56 121.67,121.67 | U14.11 121.84,122.22 121.54,121.92 | U14.10 122.3,122.86 | 122.3,122.86 121.85,122.86 R53.1 | U14.9 122.76,123.52 122.68,123.44 122.68,123.24 122.3,122.86
  Top 0.61: 121.67,121.67 121.54,121.79 121.54,121.92 R53.1 120.38,123.17 119.89,122.68 118.73,122.68 C15.2 118.25,122.94 117.6,122.94 117.12,123.42 C17.- 114.96,123.19 TVN3.TP
  Route2 0.406: v91.06,100.97 80.26,100.97 v79.12,99.82
  Route2 1.016: TVN3.TP 110.74,125.09 v89.79,125.09 44.07,125.09 v43.43,126.36
  Route3 0.305: 44.07,13.97 v43.56,13.21 | v42.93,49.4 44.07,49.4 | v42.93,102.74 44.07,102.74 | v42.93,91.57 44.07,91.57 | v44.2,76.07 45.34,76.07 | v42.93,64.64 44.07,64.64 | v42.93,37.97 44.07,37.97 | v43.56,24.64 44.7,24.64 | v42.93,119.25 44.07,119.25
  Route3 0.406: v43.43,126.36 43.18,126.75 43.18,131.32 v42.93,131.95 45.34,139.06 v45.47,144.02 45.34,155.57 v42.93,157.35 v42.93,170.05 v42.93,182.75 v42.93,197.99 v42.93,209.42 | v89.92,10.03 v89.92,21.72 v89.92,35.94 v89.92,47.37 v89.92,62.1 89.15,62.87 89.15,64.14 88.63,64.14 86.11,66.66 v86.11,73.53 86.11,76.71 79.12,83.69 v79.12,88.39 v79.12,99.82 | v89.92,207.14 v89.92,195.2 90.17,195.2 90.42,194.94 90.42,180.72 v89.92,180.21 v89.92,168.78 v89.92,156.08 v89.92,143.38 v89.92,133.22 89.92,125.22 v89.79,125.09 89.92,124.97 v89.92,117.98 89.92,114.17 90.42,113.67 v91.06,100.97
  Route3 0.61: v43.43,126.36 43.43,123.19 44.07,120.65 44.07,119.25 44.07,102.74 44.07,91.57 45.34,76.07 44.07,64.64 44.07,49.4 44.07,37.97 44.07,26.04 44.7,25.4 44.7,24.64 44.7,14.61 44.07,13.97
  BOTTOM 0.254: D0:R49.2 v42.93,209.42 41.66,210.69 D0:C3.2 D0:C4.2 | D1:R49.2 v89.92,207.14 88.65,208.41 D1:C3.2 D1:C4.2 | D2:R49.2 v42.93,197.99 41.66,199.26 D2:C3.2 D2:C4.2 | D3:R49.2 v89.92,195.2 88.65,196.47 D3:C3.2 D3:C4.2 | D4:R49.2 v42.93,182.75 41.66,184.02 D4:C3.2 D4:C4.2 | D5:R49.2 v89.92,180.21 88.65,181.48 D5:C3.2 D5:C4.2 | D6:R49.2 v42.93,170.05 41.66,171.32 D6:C3.2 D6:C4.2 | D7:R49.2 v89.92,168.78 88.65,170.05 D7:C3.2 D7:C4.2 | D8:R49.2 v42.93,157.35 41.66,158.62 D8:C3.2 D8:C4.2 | D9:R49.2 v89.92,156.08 88.65,157.35 D9:C3.2 D9:C4.2 | D10:R49.2 v45.47,144.02 44.2,145.29 D10:C3.2 D10:C4.2 | D11:R49.2 v89.92,143.38 88.65,144.65 D11:C3.2 D11:C4.2 | D13:R49.2 v42.93,131.95 41.66,133.22 D13:C3.2 D13:C4.2 | D12:R49.2 v89.92,133.22 88.65,134.49 D12:C3.2 D12:C4.2 | D15:R49.2 v42.93,119.25 41.66,120.52 D15:C3.2 D15:C4.2 | D14:R49.2 v89.92,117.98 88.65,119.25 D14:C3.2 D14:C4.2 | D16:R49.2 v42.93,102.74 41.66,104.01 D16:C3.2 D16:C4.2 | D17:R49.2 v79.12,99.82 77.85,101.09 D17:C3.2 D17:C4.2 | D18:R49.2 v42.93,91.57 41.66,92.84 D18:C3.2 D18:C4.2 | D19:R49.2 v79.12,88.39 77.85,89.66 D19:C3.2 D19:C4.2 | D20:R49.2 v44.2,76.07 42.93,77.34 D20:C3.2 D20:C4.2 | D21:R49.2 v86.11,73.53 84.84,74.8 D21:C3.2 D21:C4.2 | D22:R49.2 v42.93,64.64 41.66,65.91 D22:C3.2 D22:C4.2 | D23:R49.2 v89.92,62.1 88.65,63.37 D23:C3.2 D23:C4.2 | D24:R49.2 v42.93,49.4 41.66,50.67 D24:C3.2 D24:C4.2 | D25:R49.2 v89.92,47.37 88.65,48.64 D25:C3.2 D25:C4.2 | D26:R49.2 v42.93,37.97 41.66,39.24 D26:C3.2 D26:C4.2 | D27:R49.2 v89.92,35.94 88.65,37.21 D27:C3.2 D27:C4.2 | D28:R49.2 v43.56,24.64 42.29,25.91 D28:C3.2 D28:C4.2
  BOTTOM 0.254: D29:R49.2 v89.92,21.72 88.65,22.99 D29:C3.2 D29:C4.2 | D30:R49.2 v43.56,13.21 42.29,14.48 D30:C3.2 D30:C4.2 | D31:R49.2 v89.92,10.03 88.65,11.3 D31:C3.2 D31:C4.2
VIN+
  Top 0.305: R50.2 127.34,101.58 128.93,100
  Top 0.61: C3.2 118.68,112.3
  Top 0.813: F2.1 T4.TP | T4.TP 127.89,107.95 125.98,109.86 125.98,111.12 124.71,112.39 119.76,112.39 119.36,111.99 119,111.99 | U21.4 119,111.99 | 118.68,112.3 119,111.99 | T4.TP C4.+ 131.06,101.6 128.93,100 128.52,99.69 U22.4
VIN-  (via drill 0.6)
  Top 0.406: C28.2 132.97,115.49 132.97,115.62
  Top 1.016: F3.2 132.97,113.51 132.97,115.62 TM5.TP
  other vias: 116.46,127.64 118.36,127.64 125.35,126.36 126.62,126.36 126.62,120.02 124.71,120.02 125.98,123.83 125.98,121.92 129.16,120.02 121.54,120.02 124.71,128.91 127.25,128.91 117.73,125.09
  pour Top (no thermals): 124.08,130.18 129.16,130.18 129.16,117.47 124.08,117.47
  pour Top: 129.16,128.27 138.05,128.27 138.05,117.47 129.16,117.47
  pour Top (no thermals): 112.65,130.18 124.08,130.18 124.08,117.47 111.38,117.47 111.38,128.91
  pour BOTTOM (no thermals): 114.55,128.91 122.17,128.91 122.17,125.09 124.08,125.09 124.08,130.18 127.89,130.18 127.89,125.09 131.7,125.09 131.7,117.47 119.63,117.47 119.63,119.38 119,119.38 116.46,121.92 114.55,121.92
VTR0  (via drill 0.4, 0.5, 0.6)
  Top 0.305: U1.9 19.43,190.37 19.3,190.5 v19.3,192.41
  Route2 0.305: v19.3,205.1 25.02,205.1 v25.15,204.98
  Route3 0.305: v19.3,192.41 v19.3,205.1
  BOTTOM 0.254: D0:R50.1 26.11,205.28 v25.15,204.98
VTR1  (via drill 0.4, 0.6)
  Top 0.305: U2.9 67.44,189.1 v68.2,189.87 | v68.2,201.93 72.01,202.56 v72.14,202.69
  Route3 0.305: v68.2,189.87 v68.2,201.93
  BOTTOM 0.254: D1:R50.1 73.1,202.99 v72.14,202.69
VTR2  (via drill 0.4, 0.5)
  Top 0.305: U1.8 v25.02,189.87
  Route3 0.305: v25.02,189.87 25.02,193.42 v25.15,193.55
  BOTTOM 0.254: D2:R50.1 26.11,193.85 v25.15,193.55
VTR3  (via drill 0.4)
  Top 0.305: U2.8 68.83,188.59 69.47,189.23 72.01,189.23 72.01,190.63 v72.14,190.75
  BOTTOM 0.254: D3:R50.1 73.1,191.06 v72.14,190.75
VTR4  (via drill 0.5)
  Top 0.305: v22.48,187.96 22.35,189.36 U1.7
  Route3 0.305: v22.48,187.96 22.48,179.71 22.48,179.07 v22.48,178.44
  BOTTOM 0.305: D4:R50.1 25.7,178.61 25.65,178.56 22.61,178.56 v22.48,178.44
VTR5  (via drill 0.6)
  Top 0.305: v70.1,187.96 68.83,187.96 68.71,188.09 U2.7
  Route3 0.305: v70.1,175.26 v70.1,187.96
  BOTTOM 0.305: D5:R50.1 72.82,176.07 72.01,175.26 v70.1,175.26
VTR6  (via drill 0.5, 0.6)
  Top 0.305: U1.6 20.93,188.87 v21.21,187.96
  Route3 0.305: v21.21,165.74 v21.21,187.96
  BOTTOM 0.305: D6:R50.1 27.05,165.74 v21.21,165.74
VTR7  (via drill 0.4, 0.6)
  Top 0.305: U2.6 67.92,187.6 v68.83,186.69
  Route3 0.305: v68.83,186.69 68.83,166.37 69.47,164.47 70.99,164.47 v72.14,164.34
  BOTTOM 0.254: D7:R50.1 73.1,164.64 v72.14,164.34
VTR8  (via drill 0.4, 0.6)
  Top 0.305: U6.9 21.97,138.94 22.35,139.32 22.35,139.57 v22.48,139.7 | v22.48,153.03 25.02,153.03 v25.15,152.91
  Route3 0.305: v22.48,139.7 v22.48,153.03
  BOTTOM 0.254: D8:R50.1 26.11,153.21 v25.15,152.91
VTR9  (via drill 0.4, 0.6)
  Top 0.305: U7.9 68.33,141.48 68.58,141.73 v68.58,142.49
  Route3 0.305: v68.58,142.49 v71.76,151.64
  BOTTOM 0.254: D9:R50.1 73.1,151.94 v71.76,151.64
VTR10  (via drill 0.4, 0.6)
  Top 0.305: U6.8 v23.11,138.43
  Route2 0.305: v23.11,138.43 24.64,136.53 v27.69,139.57
  Route3 0.305: 27.56,139.45 v27.69,139.57
  BOTTOM 0.254: D10:R50.1 28.65,139.88 v27.69,139.57
VTR11  (via drill 0.4, 0.6)
  Top 0.305: U7.8 v69.47,140.97
  Route2 0.305: v69.47,140.97 70.1,140.97 v72.14,138.94
  BOTTOM 0.254: D11:R50.1 73.1,139.24 v72.14,138.94
VTR12  (via drill 0.4, 0.6)
  Top 0.305: U6.7 21.72,137.92 22.35,137.29 v22.35,136.53
  Route3 0.305: v22.35,136.53 v22.35,127.76
  BOTTOM 0.254: D13:R50.1 26.11,127.81 v22.35,127.76
VTR13  (via drill 0.4, 0.6)
  Top 0.305: U7.7 68.33,140.46 68.58,140.21 v68.58,139.19
  Route3 0.305: v68.58,139.19 v70.74,128.27
  BOTTOM 0.254: D12:R50.1 73.1,129.08 v70.74,128.27
VTR14  (via drill 0.4, 0.6)
  Top 0.305: U6.6 20.7,136.02 v20.83,135.89
  Route3 0.305: v20.83,135.89 20.83,116.59 v22.61,114.81
  BOTTOM 0.254: D15:R50.1 26.11,115.11 v22.61,114.81
VTR15  (via drill 0.4, 0.6)
  Top 0.305: U7.6 v67.06,138.18
  Route3 0.305: v67.06,138.18 67.56,117.47 v70.23,113.54
  BOTTOM 0.254: D14:R50.1 73.1,113.84 v70.23,113.54
VTR16  (via drill 0.4, 0.6)
  Top 0.305: U9.9 22.99,77.98 23.11,78.11 v23.11,80.01
  Route3 0.305: v23.11,80.01 23.11,96.52 23.75,97.16 24.64,97.16 v25.15,97.66
  BOTTOM 0.254: D16:R50.1 26.11,98.6 v25.15,97.66
VTR17  (via drill 0.4, 0.6)
  Top 0.305: U10.9 65.15,75.44 65.41,75.69 65.41,76.45 64.9,76.96 64.9,77.09 64.64,77.34 64.64,77.85 v64.39,78.11
  Route3 0.305: v64.39,78.11 64.39,79.38 60.58,83.19 60.58,83.82 59.94,84.45 59.94,93.34 v61.59,94.36
  BOTTOM 0.254: D17:R50.1 62.31,95.68 v61.59,94.36
VTR18  (via drill 0.4, 0.6)