# EAGLE board SOL_AMPV3 (EAGLE 7.6.0), part 3 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
D17:VB-  (via drill 0.4) (continued)
  Top 0.406: D17:C46.1 64.94,98.55 D17:R46.2 63.56,98.54 63.56,97.6 63.25,97.28 D17:R47.1 63.03,96.97 v61.66,97.28
  BOTTOM 0.406: D17:R50.2 61.67,97.3 v61.66,97.28
D17:VCOM  (via drill 0.4)
  Top 0.254: D17:U1.2 77.52,97.9 77.53,97.92 77.53,98.23 77.22,98.55 v75.63,98.87
  BOTTOM 0.254: v75.63,98.87 D17:C7.1 74.39,96.98 D17:R1.2
D18:AMP+
  Top 0.254: 42.59,87.42 39.43,87.44 39.13,87.74 D18:C43.2 38.39,87.74 D18:R43.2 | 42.59,87.42 42.61,88.08 42.61,88.89 D18:U1.4 | 42.59,87.42 42.61,87.44 D18:C44.1 D18:R44.1 D18:R61.2
D18:AMP-
  Top 0.254: D18:R33.2 38.36,93.81 D18:C33.2 39.45,93.81 40.07,94.42 42.62,94.42 | 42.62,94.42 D18:U1.5 | 42.62,94.42 44.5,94.42 D18:R34.1 D18:C34.1 D18:R51.2
D18:FB+
  Top 0.254: D18:R32.1 D18:R33.1 34.67,94.42 D18:C32.2 D18:R31.2
D18:FB-
  Top 0.254: D18:R43.1 36.04,89.03 | 36.04,89.03 D18:R42.1 | D18:R41.2 D18:C42.2 34.67,89.03 36.04,89.03
D18:N$1  (via drill 0.4)
  Top 0.254: D18:R51.1 D18:R49.1 | D18:R49.1 D18:R45.1 | v47.37,91.57 D18:R49.1
  BOTTOM 0.254: D18:C45.2 D18:R49.1 v47.37,91.57
D18:N$4
  Top 0.254: D18:U1.1 38.97,88.9 D18:C43.1 38.78,88.72 37.85,89.66 D18:R42.2
D18:N$5
  Top 0.254: D18:U1.8 40.51,92.96 40.39,92.84 40.07,92.84 39.75,92.52 39.13,92.52 D18:C33.1 38.05,92.5 D18:R32.2
D18:N$7  (via drill 0.4)
  Top 0.254: D18:R61.1 v47.69,89.66 48.32,90.3 48.32,92.2 D18:R35.2
  BOTTOM 0.254: D18:C35.2 D18:R39.1 45.16,89.98 46.42,89.98 46.74,89.66 v47.69,89.66
D18:N$10
  Top 0.406: D18:R41.1 30.97,87.54 D18:C41.1
D18:R31
  Top 0.406: D18:R31.1 30.97,94.64 D18:C31.1
D18:VB+
  Top 0.406: D18:R37.2 27.05,92.84 27.37,92.52 27.37,92.2 | 27.37,92.2 27.37,91.58 D18:R36.1 | D18:C36.1 27.37,92.2
D18:VB-  (via drill 0.4)
  Top 0.406: D18:C46.1 28.74,90.3 D18:R46.2 27.37,90.28 27.37,89.34 27.05,89.03 D18:R47.1 26.84,88.71 v25.46,89.03
  BOTTOM 0.406: D18:R50.2 25.48,89.04 v25.46,89.03
D18:VCOM  (via drill 0.4)
  Top 0.254: D18:U1.2 41.33,89.65 41.34,89.66 41.34,89.98 41.02,90.3 v39.43,90.61
  BOTTOM 0.254: v39.43,90.61 D18:C7.1 38.19,88.72 D18:R1.2
D19:AMP+
  Top 0.254: 78.79,84.25 75.63,84.26 75.33,84.57 D19:C43.2 74.59,84.57 D19:R43.2 | 78.79,84.25 78.8,84.9 78.8,85.71 D19:U1.4 | 78.79,84.25 78.8,84.26 D19:C44.1 D19:R44.1 D19:R61.2
D19:AMP-
  Top 0.254: D19:R33.2 74.56,90.63 D19:C33.2 75.64,90.63 76.26,91.25 78.82,91.25 | 78.82,91.25 D19:U1.5 | 78.82,91.25 80.69,91.25 D19:R34.1 D19:C34.1 D19:R51.2
D19:FB+
  Top 0.254: D19:R32.1 D19:R33.1 70.87,91.25 D19:C32.2 D19:R31.2
D19:FB-
  Top 0.254: D19:R43.1 72.24,85.85 | 72.24,85.85 D19:R42.1 | D19:R41.2 D19:C42.2 70.87,85.85 72.24,85.85
D19:N$1  (via drill 0.4)
  Top 0.254: D19:R51.1 D19:R49.1 | D19:R49.1 D19:R45.1 | v83.57,88.39 D19:R49.1
  BOTTOM 0.254: D19:C45.2 D19:R49.1 v83.57,88.39
D19:N$4
  Top 0.254: D19:U1.1 75.17,85.72 D19:C43.1 74.98,85.55 74.04,86.49 D19:R42.2
D19:N$5
  Top 0.254: D19:U1.8 76.71,89.79 76.58,89.66 76.26,89.66 75.95,89.34 75.33,89.34 D19:C33.1 74.24,89.33 D19:R32.2
D19:N$7  (via drill 0.4)
  Top 0.254: D19:R61.1 v83.88,86.49 84.52,87.12 84.52,89.03 D19:R35.2
  BOTTOM 0.254: D19:C35.2 D19:R39.1 81.36,86.81 82.61,86.81 82.93,86.49 v83.88,86.49
D19:N$10
  Top 0.406: D19:R41.1 67.17,84.37 D19:C41.1
D19:R31
  Top 0.406: D19:R31.1 67.17,91.47 D19:C31.1
D19:VB+
  Top 0.406: D19:R37.2 63.25,89.66 63.56,89.34 63.56,89.03 | 63.56,89.03 63.56,88.41 D19:R36.1 | D19:C36.1 63.56,89.03
D19:VB-  (via drill 0.4)
  Top 0.406: D19:C46.1 64.94,87.12 D19:R46.2 63.56,87.11 63.56,86.17 63.25,85.85 D19:R47.1 63.03,85.53 v61.66,85.85
  BOTTOM 0.406: D19:R50.2 61.67,85.87 v61.66,85.85
D19:VCOM  (via drill 0.4)
  Top 0.254: D19:U1.2 77.52,86.47 77.53,86.49 77.53,86.81 77.22,87.12 v75.63,87.44
  BOTTOM 0.254: v75.63,87.44 D19:C7.1 74.39,85.55 D19:R1.2
D20:AMP+
  Top 0.254: 43.86,71.93 40.7,71.94 40.4,72.25 D20:C43.2 39.66,72.25 D20:R43.2 | 43.86,71.93 43.88,72.58 43.88,73.39 D20:U1.4 | 43.86,71.93 43.88,71.94 D20:C44.1 D20:R44.1 D20:R61.2
D20:AMP-
  Top 0.254: D20:R33.2 39.63,78.31 D20:C33.2 40.72,78.31 41.34,78.93 43.89,78.93 | 43.89,78.93 D20:U1.5 | 43.89,78.93 45.77,78.93 D20:R34.1 D20:C34.1 D20:R51.2
D20:FB+
  Top 0.254: D20:R32.1 D20:R33.1 35.94,78.93 D20:C32.2 D20:R31.2
D20:FB-
  Top 0.254: D20:R43.1 37.31,73.53 | 37.31,73.53 D20:R42.1 | D20:R41.2 D20:C42.2 35.94,73.53 37.31,73.53
D20:N$1  (via drill 0.4)
  Top 0.254: D20:R51.1 D20:R49.1 | D20:R49.1 D20:R45.1 | v48.64,76.07 D20:R49.1
  BOTTOM 0.254: D20:C45.2 D20:R49.1 v48.64,76.07
D20:N$4
  Top 0.254: D20:U1.1 40.24,73.41 D20:C43.1 40.05,73.23 39.12,74.17 D20:R42.2
D20:N$5
  Top 0.254: D20:U1.8 41.78,77.47 41.66,77.34 41.34,77.34 41.02,77.03 40.4,77.03 D20:C33.1 39.32,77.01 D20:R32.2
D20:N$7  (via drill 0.4)
  Top 0.254: D20:R61.1 v48.96,74.17 49.59,74.8 49.59,76.71 D20:R35.2
  BOTTOM 0.254: D20:C35.2 D20:R39.1 46.43,74.49 47.69,74.49 48.01,74.17 v48.96,74.17
D20:N$10
  Top 0.406: D20:R41.1 32.24,72.05 D20:C41.1
D20:R31
  Top 0.406: D20:R31.1 32.24,79.14 D20:C31.1
D20:VB+
  Top 0.406: D20:R37.2 28.32,77.34 28.64,77.03 28.64,76.71 | 28.64,76.71 28.64,76.09 D20:R36.1 | D20:C36.1 28.64,76.71
D20:VB-  (via drill 0.4)
  Top 0.406: D20:C46.1 30.01,74.8 D20:R46.2 28.64,74.79 28.64,73.85 28.32,73.53 D20:R47.1 28.11,73.22 v26.73,73.53
  BOTTOM 0.406: D20:R50.2 26.75,73.55 v26.73,73.53
D20:VCOM  (via drill 0.4)
  Top 0.254: D20:U1.2 42.6,74.16 42.61,74.17 42.61,74.49 42.29,74.8 v40.7,75.12
  BOTTOM 0.254: v40.7,75.12 D20:C7.1 39.46,73.23 D20:R1.2
D21:AMP+
  Top 0.254: 85.77,69.39 82.61,69.41 82.31,69.71 D21:C43.2 81.57,69.71 D21:R43.2 | 85.77,69.39 85.79,70.04 85.79,70.85 D21:U1.4 | 85.77,69.39 85.79,69.41 D21:C44.1 D21:R44.1 D21:R61.2
D21:AMP-
  Top 0.254: D21:R33.2 81.54,75.77 D21:C33.2 82.63,75.77 83.25,76.39 85.8,76.39 | 85.8,76.39 D21:U1.5 | 85.8,76.39 87.68,76.39 D21:R34.1 D21:C34.1 D21:R51.2
D21:FB+
  Top 0.254: D21:R32.1 D21:R33.1 77.85,76.39 D21:C32.2 D21:R31.2
D21:FB-
  Top 0.254: D21:R43.1 79.22,70.99 | 79.22,70.99 D21:R42.1 | D21:R41.2 D21:C42.2 77.85,70.99 79.22,70.99
D21:N$1  (via drill 0.4)
  Top 0.254: D21:R51.1 D21:R49.1 | D21:R49.1 D21:R45.1 | v90.55,73.53 D21:R49.1
  BOTTOM 0.254: D21:C45.2 D21:R49.1 v90.55,73.53
D21:N$4
  Top 0.254: D21:U1.1 82.15,70.87 D21:C43.1 81.96,70.69 81.03,71.63 D21:R42.2
D21:N$5
  Top 0.254: D21:U1.8 83.69,74.93 83.57,74.8 83.25,74.8 82.93,74.49 82.31,74.49 D21:C33.1 81.23,74.47 D21:R32.2
D21:N$7  (via drill 0.4)
  Top 0.254: D21:R61.1 v90.87,71.63 91.5,72.26 91.5,74.17 D21:R35.2
  BOTTOM 0.254: D21:C35.2 D21:R39.1 88.34,71.94 89.6,71.94 89.92,71.63 v90.87,71.63
D21:N$10
  Top 0.406: D21:R41.1 74.15,69.51 D21:C41.1
D21:R31
  Top 0.406: D21:R31.1 74.15,76.61 D21:C31.1
D21:VB+
  Top 0.406: D21:R37.2 70.23,74.8 70.55,74.49 70.55,74.17 | 70.55,74.17 70.55,73.55 D21:R36.1 | D21:C36.1 70.55,74.17
D21:VB-  (via drill 0.4)
  Top 0.406: D21:C46.1 71.92,72.26 D21:R46.2 70.55,72.25 70.55,71.31 70.23,70.99 D21:R47.1 70.02,70.67 v68.64,70.99
  BOTTOM 0.406: D21:R50.2 68.66,71.01 v68.64,70.99
D21:VCOM  (via drill 0.4)
  Top 0.254: D21:U1.2 84.51,71.61 84.52,71.63 84.52,71.94 84.2,72.26 v82.61,72.58
  BOTTOM 0.254: v82.61,72.58 D21:C7.1 81.37,70.69 D21:R1.2
D22:AMP+
  Top 0.254: 42.59,60.5 39.43,60.52 39.13,60.82 D22:C43.2 38.39,60.82 D22:R43.2 | 42.59,60.5 42.61,61.15 42.61,61.96 D22:U1.4 | 42.59,60.5 42.61,60.52 D22:C44.1 D22:R44.1 D22:R61.2
D22:AMP-
  Top 0.254: D22:R33.2 38.36,66.88 D22:C33.2 39.45,66.88 40.07,67.5 42.62,67.5 | 42.62,67.5 D22:U1.5 | 42.62,67.5 44.5,67.5 D22:R34.1 D22:C34.1 D22:R51.2
D22:FB+
  Top 0.254: D22:R32.1 D22:R33.1 34.67,67.5 D22:C32.2 D22:R31.2
D22:FB-
  Top 0.254: D22:R43.1 36.04,62.1 | 36.04,62.1 D22:R42.1 | D22:R41.2 D22:C42.2 34.67,62.1 36.04,62.1
D22:N$1  (via drill 0.4)
  Top 0.254: D22:R51.1 D22:R49.1 | D22:R49.1 D22:R45.1 | v47.37,64.64 D22:R49.1
  BOTTOM 0.254: D22:C45.2 D22:R49.1 v47.37,64.64
D22:N$4
  Top 0.254: D22:U1.1 38.97,61.98 D22:C43.1 38.78,61.8 37.85,62.74 D22:R42.2
D22:N$5
  Top 0.254: D22:U1.8 40.51,66.04 40.39,65.91 40.07,65.91 39.75,65.6 39.13,65.6 D22:C33.1 38.05,65.58 D22:R32.2
D22:N$7  (via drill 0.4)
  Top 0.254: D22:R61.1 v47.69,62.74 48.32,63.37 48.32,65.28 D22:R35.2
  BOTTOM 0.254: D22:C35.2 D22:R39.1 45.16,63.06 46.42,63.06 46.74,62.74 v47.69,62.74
D22:N$10
  Top 0.406: D22:R41.1 30.97,60.62 D22:C41.1
D22:R31
  Top 0.406: D22:R31.1 30.97,67.72 D22:C31.1
D22:VB+
  Top 0.406: D22:R37.2 27.05,65.91 27.37,65.6 27.37,65.28 | 27.37,65.28 27.37,64.66 D22:R36.1 | D22:C36.1 27.37,65.28
D22:VB-  (via drill 0.4)
  Top 0.406: D22:C46.1 28.74,63.37 D22:R46.2 27.37,63.36 27.37,62.42 27.05,62.1 D22:R47.1 26.84,61.78 v25.46,62.1
  BOTTOM 0.406: D22:R50.2 25.48,62.12 v25.46,62.1
D22:VCOM  (via drill 0.4)
  Top 0.254: D22:U1.2 41.33,62.73 41.34,62.74 41.34,63.06 41.02,63.37 v39.43,63.69
  BOTTOM 0.254: v39.43,63.69 D22:C7.1 38.19,61.8 D22:R1.2
D23:AMP+
  Top 0.254: 89.58,57.96 86.42,57.98 86.12,58.28 D23:C43.2 85.38,58.28 D23:R43.2 | 89.58,57.96 89.6,58.61 89.6,59.42 D23:U1.4 | 89.58,57.96 89.6,57.98 D23:C44.1 D23:R44.1 D23:R61.2
D23:AMP-
  Top 0.254: D23:R33.2 85.35,64.34 D23:C33.2 86.44,64.34 87.06,64.96 89.61,64.96 | 89.61,64.96 D23:U1.5 | 89.61,64.96 91.49,64.96 D23:R34.1 D23:C34.1 D23:R51.2
D23:FB+
  Top 0.254: D23:R32.1 D23:R33.1 81.66,64.96 D23:C32.2 D23:R31.2
D23:FB-
  Top 0.254: D23:R43.1 83.03,59.56 | 83.03,59.56 D23:R42.1 | D23:R41.2 D23:C42.2 81.66,59.56 83.03,59.56
D23:N$1  (via drill 0.4)
  Top 0.254: D23:R51.1 D23:R49.1 | D23:R49.1 D23:R45.1 | v94.36,62.1 D23:R49.1
  BOTTOM 0.254: D23:C45.2 D23:R49.1 v94.36,62.1
D23:N$4
  Top 0.254: D23:U1.1 85.96,59.44 D23:C43.1 85.77,59.26 84.84,60.2 D23:R42.2
D23:N$5
  Top 0.254: D23:U1.8 87.5,63.5 87.38,63.37 87.06,63.37 86.74,63.06 86.12,63.06 D23:C33.1 85.04,63.04 D23:R32.2
D23:N$7  (via drill 0.4)
  Top 0.254: D23:R61.1 v94.68,60.2 95.31,60.83 95.31,62.74 D23:R35.2
  BOTTOM 0.254: D23:C35.2 D23:R39.1 92.15,60.52 93.41,60.52 93.73,60.2 v94.68,60.2
D23:N$10
  Top 0.406: D23:R41.1 77.96,58.08 D23:C41.1
D23:R31
  Top 0.406: D23:R31.1 77.96,65.17 D23:C31.1
D23:VB+
  Top 0.406: D23:R37.2 74.04,63.37 74.36,63.06 74.36,62.74 | 74.36,62.74 74.36,62.12 D23:R36.1 | D23:C36.1 74.36,62.74
D23:VB-  (via drill 0.4)
  Top 0.406: D23:C46.1 75.73,60.83 D23:R46.2 74.36,60.82 74.36,59.88 74.04,59.56 D23:R47.1 73.83,59.24 v72.45,59.56
  BOTTOM 0.406: D23:R50.2 72.47,59.58 v72.45,59.56
D23:VCOM  (via drill 0.4)
  Top 0.254: D23:U1.2 88.32,60.19 88.33,60.2 88.33,60.52 88.01,60.83 v86.42,61.15
  BOTTOM 0.254: v86.42,61.15 D23:C7.1 85.18,59.26 D23:R1.2
D24:AMP+
  Top 0.254: 42.59,45.26 39.43,45.28 39.13,45.58 D24:C43.2 38.39,45.58 D24:R43.2 | 42.59,45.26 42.61,45.91 42.61,46.72 D24:U1.4 | 42.59,45.26 42.61,45.28 D24:C44.1 D24:R44.1 D24:R61.2
D24:AMP-
  Top 0.254: D24:R33.2 38.36,51.64 D24:C33.2 39.45,51.64 40.07,52.26 42.62,52.26 | 42.62,52.26 D24:U1.5 | 42.62,52.26 44.5,52.26 D24:R34.1 D24:C34.1 D24:R51.2
D24:FB+
  Top 0.254: D24:R32.1 D24:R33.1 34.67,52.26 D24:C32.2 D24:R31.2
D24:FB-
  Top 0.254: D24:R43.1 36.04,46.86 | 36.04,46.86 D24:R42.1 | D24:R41.2 D24:C42.2 34.67,46.86 36.04,46.86
D24:N$1  (via drill 0.4)
  Top 0.254: D24:R51.1 D24:R49.1 | D24:R49.1 D24:R45.1 | v47.37,49.4 D24:R49.1
  BOTTOM 0.254: D24:C45.2 D24:R49.1 v47.37,49.4
D24:N$4
  Top 0.254: D24:U1.1 38.97,46.74 D24:C43.1 38.78,46.56 37.85,47.5 D24:R42.2
D24:N$5
  Top 0.254: D24:U1.8 40.51,50.8 40.39,50.67 40.07,50.67 39.75,50.35 39.13,50.35 D24:C33.1 38.05,50.34 D24:R32.2
D24:N$7  (via drill 0.4)
  Top 0.254: D24:R61.1 v47.69,47.5 48.32,48.13 48.32,50.04 D24:R35.2
  BOTTOM 0.254: D24:C35.2 D24:R39.1 45.16,47.82 46.42,47.82 46.74,47.5 v47.69,47.5
D24:N$10
  Top 0.406: D24:R41.1 30.97,45.38 D24:C41.1
D24:R31
  Top 0.406: D24:R31.1 30.97,52.48 D24:C31.1
D24:VB+
  Top 0.406: D24:R37.2 27.05,50.67 27.37,50.35 27.37,50.04 | 27.37,50.04 27.37,49.42 D24:R36.1 | D24:C36.1 27.37,50.04
D24:VB-  (via drill 0.4)
  Top 0.406: D24:C46.1 28.74,48.13 D24:R46.2 27.37,48.12 27.37,47.18 27.05,46.86 D24:R47.1 26.84,46.55 v25.46,46.86
  BOTTOM 0.406: D24:R50.2 25.48,46.88 v25.46,46.86
D24:VCOM  (via drill 0.4)
  Top 0.254: D24:U1.2 41.33,47.48 41.34,47.5 41.34,47.82 41.02,48.13 v39.43,48.45
  BOTTOM 0.254: v39.43,48.45 D24:C7.1 38.19,46.56 D24:R1.2
D25:AMP+
  Top 0.254: 89.58,43.23 86.42,43.24 86.12,43.55 D25:C43.2 85.38,43.55 D25:R43.2 | 89.58,43.23 89.6,43.88 89.6,44.69 D25:U1.4 | 89.58,43.23 89.6,43.24 D25:C44.1 D25:R44.1 D25:R61.2
D25:AMP-
  Top 0.254: D25:R33.2 85.35,49.61 D25:C33.2 86.44,49.61 87.06,50.23 89.61,50.23 | 89.61,50.23 D25:U1.5 | 89.61,50.23 91.49,50.23 D25:R34.1 D25:C34.1 D25:R51.2
D25:FB+
  Top 0.254: D25:R32.1 D25:R33.1 81.66,50.23 D25:C32.2 D25:R31.2
D25:FB-
  Top 0.254: D25:R43.1 83.03,44.83 | 83.03,44.83 D25:R42.1 | D25:R41.2 D25:C42.2 81.66,44.83 83.03,44.83
D25:N$1  (via drill 0.4)
  Top 0.254: D25:R51.1 D25:R49.1 | D25:R49.1 D25:R45.1 | v94.36,47.37 D25:R49.1
  BOTTOM 0.254: D25:C45.2 D25:R49.1 v94.36,47.37
D25:N$4
  Top 0.254: D25:U1.1 85.96,44.7 D25:C43.1 85.77,44.53 84.84,45.47 D25:R42.2
D25:N$5
  Top 0.254: D25:U1.8 87.5,48.77 87.38,48.64 87.06,48.64 86.74,48.32 86.12,48.32 D25:C33.1 85.04,48.31 D25:R32.2
D25:N$7  (via drill 0.4)
  Top 0.254: D25:R61.1 v94.68,45.47 95.31,46.1 95.31,48.01 D25:R35.2
  BOTTOM 0.254: D25:C35.2 D25:R39.1 92.15,45.78 93.41,45.78 93.73,45.47 v94.68,45.47
D25:N$10
  Top 0.406: D25:R41.1 77.96,43.35 D25:C41.1
D25:R31
  Top 0.406: D25:R31.1 77.96,50.44 D25:C31.1
D25:VB+
  Top 0.406: D25:R37.2 74.04,48.64 74.36,48.32 74.36,48.01 | 74.36,48.01 74.36,47.39 D25:R36.1 | D25:C36.1 74.36,48.01
D25:VB-  (via drill 0.4)
  Top 0.406: D25:C46.1 75.73,46.1 D25:R46.2 74.36,46.09 74.36,45.15 74.04,44.83 D25:R47.1 73.83,44.51 v72.45,44.83
  BOTTOM 0.406: D25:R50.2 72.47,44.85 v72.45,44.83
D25:VCOM  (via drill 0.4)
  Top 0.254: D25:U1.2 88.32,45.45 88.33,45.47 88.33,45.78 88.01,46.1 v86.42,46.42
  BOTTOM 0.254: v86.42,46.42 D25:C7.1 85.18,44.53 D25:R1.2
D26:AMP+
  Top 0.254: 42.59,33.83 39.43,33.85 39.13,34.15 D26:C43.2 38.39,34.15 D26:R43.2 | 42.59,33.83 42.61,34.48 42.61,35.29 D26:U1.4 | 42.59,33.83 42.61,33.85 D26:C44.1 D26:R44.1 D26:R61.2
D26:AMP-
  Top 0.254: D26:R33.2 38.36,40.21 D26:C33.2 39.45,40.21 40.07,40.83 42.62,40.83 | 42.62,40.83 D26:U1.5 | 42.62,40.83 44.5,40.83 D26:R34.1 D26:C34.1 D26:R51.2
D26:FB+
  Top 0.254: D26:R32.1 D26:R33.1 34.67,40.83 D26:C32.2 D26:R31.2
D26:FB-
  Top 0.254: D26:R43.1 36.04,35.43 | 36.04,35.43 D26:R42.1 | D26:R41.2 D26:C42.2 34.67,35.43 36.04,35.43
D26:N$1  (via drill 0.4)
  Top 0.254: D26:R51.1 D26:R49.1 | D26:R49.1 D26:R45.1 | v47.37,37.97 D26:R49.1
  BOTTOM 0.254: D26:C45.2 D26:R49.1 v47.37,37.97
D26:N$4
  Top 0.254: D26:U1.1 38.97,35.31 D26:C43.1 38.78,35.13 37.85,36.07 D26:R42.2
D26:N$5
  Top 0.254: D26:U1.8 40.51,39.37 40.39,39.24 40.07,39.24 39.75,38.92 39.13,38.92 D26:C33.1 38.05,38.91 D26:R32.2
D26:N$7  (via drill 0.4)
  Top 0.254: D26:R61.1 v47.69,36.07 48.32,36.7 48.32,38.61 D26:R35.2
  BOTTOM 0.254: D26:C35.2 D26:R39.1 45.16,36.39 46.42,36.39 46.74,36.07 v47.69,36.07
D26:N$10
  Top 0.406: D26:R41.1 30.97,33.95 D26:C41.1
D26:R31
  Top 0.406: D26:R31.1 30.97,41.05 D26:C31.1
D26:VB+
  Top 0.406: D26:R37.2 27.05,39.24 27.37,38.92 27.37,38.61 | 27.37,38.61 27.37,37.99 D26:R36.1 | D26:C36.1 27.37,38.61
D26:VB-  (via drill 0.4)
  Top 0.406: D26:C46.1 28.74,36.7 D26:R46.2 27.37,36.69 27.37,35.75 27.05,35.43 D26:R47.1 26.84,35.12 v25.46,35.43
  BOTTOM 0.406: D26:R50.2 25.48,35.45 v25.46,35.43
D26:VCOM  (via drill 0.4)
  Top 0.254: D26:U1.2 41.33,36.05 41.34,36.07 41.34,36.39 41.02,36.7 v39.43,37.02
  BOTTOM 0.254: v39.43,37.02 D26:C7.1 38.19,35.13 D26:R1.2
D27:AMP+
  Top 0.254: 89.58,31.8 86.42,31.81 86.12,32.12 D27:C43.2 85.38,32.12 D27:R43.2 | 89.58,31.8 89.6,32.45 89.6,33.26 D27:U1.4 | 89.58,31.8 89.6,31.81 D27:C44.1 D27:R44.1 D27:R61.2
D27:AMP-
  Top 0.254: D27:R33.2 85.35,38.18 D27:C33.2 86.44,38.18 87.06,38.8 89.61,38.8 | 89.61,38.8 D27:U1.5 | 89.61,38.8 91.49,38.8 D27:R34.1 D27:C34.1 D27:R51.2
D27:FB+
  Top 0.254: D27:R32.1 D27:R33.1 81.66,38.8 D27:C32.2 D27:R31.2
D27:FB-
  Top 0.254: D27:R43.1 83.03,33.4 | 83.03,33.4 D27:R42.1 | D27:R41.2 D27:C42.2 81.66,33.4 83.03,33.4
D27:N$1  (via drill 0.4)
  Top 0.254: D27:R51.1 D27:R49.1 | D27:R49.1 D27:R45.1 | v94.36,35.94 D27:R49.1
  BOTTOM 0.254: D27:C45.2 D27:R49.1 v94.36,35.94
D27:N$4
  Top 0.254: D27:U1.1 85.96,33.27 D27:C43.1 85.77,33.1 84.84,34.04 D27:R42.2
D27:N$5
  Top 0.254: D27:U1.8 87.5,37.34 87.38,37.21 87.06,37.21 86.74,36.89 86.12,36.89 D27:C33.1 85.04,36.88 D27:R32.2
D27:N$7  (via drill 0.4)
  Top 0.254: D27:R61.1 v94.68,34.04 95.31,34.67 95.31,36.58 D27:R35.2
  BOTTOM 0.254: D27:C35.2 D27:R39.1 92.15,34.35 93.41,34.35 93.73,34.04 v94.68,34.04
D27:N$10
  Top 0.406: D27:R41.1 77.96,31.92 D27:C41.1
D27:R31
  Top 0.406: D27:R31.1 77.96,39.01 D27:C31.1
D27:VB+
  Top 0.406: D27:R37.2 74.04,37.21 74.36,36.89 74.36,36.58 | 74.36,36.58 74.36,35.96 D27:R36.1 | D27:C36.1 74.36,36.58
D27:VB-  (via drill 0.4)
  Top 0.406: D27:C46.1 75.73,34.67 D27:R46.2 74.36,34.66 74.36,33.72 74.04,33.4 D27:R47.1 73.83,33.08 v72.45,33.4
  BOTTOM 0.406: D27:R50.2 72.47,33.42 v72.45,33.4
D27:VCOM  (via drill 0.4)
  Top 0.254: D27:U1.2 88.32,34.02 88.33,34.04 88.33,34.35 88.01,34.67 v86.42,34.99
  BOTTOM 0.254: v86.42,34.99 D27:C7.1 85.18,33.1 D27:R1.2
D28:AMP+
  Top 0.254: 43.23,20.5 40.07,20.51 39.77,20.81 D28:C43.2 39.03,20.81 D28:R43.2 | 43.23,20.5 43.24,21.14 43.24,21.96 D28:U1.4 | 43.23,20.5 43.24,20.51 D28:C44.1 D28:R44.1 D28:R61.2
D28:AMP-
  Top 0.254: D28:R33.2 39,26.88 D28:C33.2 40.08,26.88 40.7,27.5 43.26,27.5 | 43.26,27.5 D28:U1.5 | 43.26,27.5 45.13,27.5 D28:R34.1 D28:C34.1 D28:R51.2
D28:FB+
  Top 0.254: D28:R32.1 D28:R33.1 35.31,27.5 D28:C32.2 D28:R31.2
D28:FB-
  Top 0.254: D28:R43.1 36.68,22.1 | 36.68,22.1 D28:R42.1 | D28:R41.2 D28:C42.2 35.31,22.1 36.68,22.1
D28:N$1  (via drill 0.4)
  Top 0.254: D28:R51.1 D28:R49.1 | D28:R49.1 D28:R45.1 | v48.01,24.64 D28:R49.1
  BOTTOM 0.254: D28:C45.2 D28:R49.1 v48.01,24.64
D28:N$4
  Top 0.254: D28:U1.1 39.61,21.97 D28:C43.1 39.42,21.8 38.48,22.73 D28:R42.2
D28:N$5
  Top 0.254: D28:U1.8 41.15,26.04 41.02,25.91 40.7,25.91 40.39,25.59 39.77,25.59 D28:C33.1 38.68,25.58 D28:R32.2
D28:N$7  (via drill 0.4)
  Top 0.254: D28:R61.1 v48.32,22.73 48.96,23.37 48.96,25.27 D28:R35.2
  BOTTOM 0.254: D28:C35.2 D28:R39.1 45.8,23.05 47.05,23.05 47.37,22.73 v48.32,22.73
D28:N$10
  Top 0.406: D28:R41.1 31.61,20.61 D28:C41.1
D28:R31
  Top 0.406: D28:R31.1 31.61,27.71 D28:C31.1
D28:VB+
  Top 0.406: D28:R37.2 27.69,25.91 28,25.59 28,25.27 | 28,25.27 28,24.65 D28:R36.1 | D28:C36.1 28,25.27
D28:VB-  (via drill 0.4)
  Top 0.406: D28:C46.1 29.38,23.37 D28:R46.2 28,23.35 28,22.42 27.69,22.1 D28:R47.1 27.47,21.78 v26.1,22.1
  BOTTOM 0.406: D28:R50.2 26.11,22.11 v26.1,22.1
D28:VCOM  (via drill 0.4)
  Top 0.254: D28:U1.2 41.96,22.72 41.97,22.73 41.97,23.05 41.66,23.37 v40.07,23.69
  BOTTOM 0.254: v40.07,23.69 D28:C7.1 38.83,21.8 D28:R1.2
D29:AMP+
  Top 0.254: 89.58,17.57 86.42,17.59 86.12,17.89 D29:C43.2 85.38,17.89 D29:R43.2 | 89.58,17.57 89.6,18.22 89.6,19.04 D29:U1.4 | 89.58,17.57 89.6,17.59 D29:C44.1 D29:R44.1 D29:R61.2
D29:AMP-
  Top 0.254: D29:R33.2 85.35,23.95 D29:C33.2 86.44,23.95 87.06,24.57 89.61,24.57 | 89.61,24.57 D29:U1.5 | 89.61,24.57 91.49,24.57 D29:R34.1 D29:C34.1 D29:R51.2
D29:FB+
  Top 0.254: D29:R32.1 D29:R33.1 81.66,24.57 D29:C32.2 D29:R31.2
D29:FB-
  Top 0.254: D29:R43.1 83.03,19.18 | 83.03,19.18 D29:R42.1 | D29:R41.2 D29:C42.2 81.66,19.18 83.03,19.18
D29:N$1  (via drill 0.4)
  Top 0.254: D29:R51.1 D29:R49.1 | D29:R49.1 D29:R45.1 | v94.36,21.72 D29:R49.1
  BOTTOM 0.254: D29:C45.2 D29:R49.1 v94.36,21.72
D29:N$4
  Top 0.254: D29:U1.1 85.96,19.05 D29:C43.1 85.77,18.88 84.84,19.81 D29:R42.2
D29:N$5
  Top 0.254: D29:U1.8 87.5,23.11 87.38,22.99 87.06,22.99 86.74,22.67 86.12,22.67 D29:C33.1 85.04,22.65 D29:R32.2
D29:N$7  (via drill 0.4)
  Top 0.254: D29:R61.1 v94.68,19.81 95.31,20.45 95.31,22.35 D29:R35.2
  BOTTOM 0.254: D29:C35.2 D29:R39.1 92.15,20.13 93.41,20.13 93.73,19.81 v94.68,19.81
D29:N$10
  Top 0.406: D29:R41.1 77.96,17.69 D29:C41.1
D29:R31
  Top 0.406: D29:R31.1 77.96,24.79 D29:C31.1
D29:VB+
  Top 0.406: D29:R37.2 74.04,22.99 74.36,22.67 74.36,22.35 | 74.36,22.35 74.36,21.73 D29:R36.1 | D29:C36.1 74.36,22.35
D29:VB-  (via drill 0.4)
  Top 0.406: D29:C46.1 75.73,20.45 D29:R46.2 74.36,20.43 74.36,19.49 74.04,19.18 D29:R47.1 73.83,18.86 v72.45,19.18
  BOTTOM 0.406: D29:R50.2 72.47,19.19 v72.45,19.18
D29:VCOM  (via drill 0.4)
  Top 0.254: D29:U1.2 88.32,19.8 88.33,19.81 88.33,20.13 88.01,20.45 v86.42,20.77
  BOTTOM 0.254: v86.42,20.77 D29:C7.1 85.18,18.88 D29:R1.2
D30:AMP+
  Top 0.254: 43.23,9.07 40.07,9.08 39.77,9.38 D30:C43.2 39.03,9.38 D30:R43.2 | 43.23,9.07 43.24,9.72 43.24,10.53 D30:U1.4 | 43.23,9.07 43.24,9.08 D30:C44.1 D30:R44.1 D30:R61.2
D30:AMP-
  Top 0.254: D30:R33.2 39,15.45 D30:C33.2 40.08,15.45 40.7,16.07 43.26,16.07 | 43.26,16.07 D30:U1.5 | 43.26,16.07 45.13,16.07 D30:R34.1 D30:C34.1 D30:R51.2
D30:FB+
  Top 0.254: D30:R32.1 D30:R33.1 35.31,16.07 D30:C32.2 D30:R31.2
D30:FB-
  Top 0.254: D30:R43.1 36.68,10.67 | 36.68,10.67 D30:R42.1 | D30:R41.2 D30:C42.2 35.31,10.67 36.68,10.67
D30:N$1  (via drill 0.4)
  Top 0.254: D30:R51.1 D30:R49.1 | D30:R49.1 D30:R45.1 | v48.01,13.21 D30:R49.1
  BOTTOM 0.254: D30:C45.2 D30:R49.1 v48.01,13.21
D30:N$4
  Top 0.254: D30:U1.1 39.61,10.54 D30:C43.1 39.42,10.37 38.48,11.3 D30:R42.2
D30:N$5
  Top 0.254: D30:U1.8 41.15,14.61 41.02,14.48 40.7,14.48 40.39,14.16 39.77,14.16 D30:C33.1 38.68,14.15 D30:R32.2
D30:N$7  (via drill 0.4)
  Top 0.254: D30:R61.1 v48.32,11.3 48.96,11.94 48.96,13.84 D30:R35.2
  BOTTOM 0.254: D30:C35.2 D30:R39.1 45.8,11.62 47.05,11.62 47.37,11.3 v48.32,11.3
D30:N$10
  Top 0.406: D30:R41.1 31.61,9.18 D30:C41.1
D30:R31
  Top 0.406: D30:R31.1 31.61,16.28 D30:C31.1
D30:VB+
  Top 0.406: D30:R37.2 27.69,14.48 28,14.16 28,13.84 | 28,13.84 28,13.22 D30:R36.1 | D30:C36.1 28,13.84
D30:VB-  (via drill 0.4)
  Top 0.406: D30:C46.1 29.38,11.94 D30:R46.2 28,11.92 28,10.99 27.69,10.67 D30:R47.1 27.47,10.35 v26.1,10.67
  BOTTOM 0.406: D30:R50.2 26.11,10.68 v26.1,10.67
D30:VCOM  (via drill 0.4)
  Top 0.254: D30:U1.2 41.96,11.29 41.97,11.3 41.97,11.62 41.66,11.94 v40.07,12.26
  BOTTOM 0.254: v40.07,12.26 D30:C7.1 38.83,10.37 D30:R1.2
D31:AMP+
  Top 0.254: 89.58,5.89 86.42,5.91 86.12,6.21 D31:C43.2 85.38,6.21 D31:R43.2 | 89.58,5.89 89.6,6.54 89.6,7.35 D31:U1.4 | 89.58,5.89 89.6,5.91 D31:C44.1 D31:R44.1 D31:R61.2
D31:AMP-
  Top 0.254: D31:R33.2 85.35,12.27 D31:C33.2 86.44,12.27 87.06,12.89 89.61,12.89 | 89.61,12.89 D31:U1.5 | 89.61,12.89 91.49,12.89 D31:R34.1 D31:C34.1 D31:R51.2
D31:FB+
  Top 0.254: D31:R32.1 D31:R33.1 81.66,12.89 D31:C32.2 D31:R31.2
D31:FB-
  Top 0.254: D31:R43.1 83.03,7.49 | 83.03,7.49 D31:R42.1 | D31:R41.2 D31:C42.2 81.66,7.49 83.03,7.49
D31:N$1  (via drill 0.4)
  Top 0.254: D31:R51.1 D31:R49.1 | D31:R49.1 D31:R45.1 | v94.36,10.03 D31:R49.1
  BOTTOM 0.254: D31:C45.2 D31:R49.1 v94.36,10.03
D31:N$4
  Top 0.254: D31:U1.1 85.96,7.37 D31:C43.1 85.77,7.19 84.84,8.13 D31:R42.2
D31:N$5
  Top 0.254: D31:U1.8 87.5,11.43 87.38,11.3 87.06,11.3 86.74,10.99 86.12,10.99 D31:C33.1 85.04,10.97 D31:R32.2
D31:N$7  (via drill 0.4)
  Top 0.254: D31:R61.1 v94.68,8.13 95.31,8.76 95.31,10.67 D31:R35.2
  BOTTOM 0.254: D31:C35.2 D31:R39.1 92.15,8.45 93.41,8.45 93.73,8.13 v94.68,8.13
D31:N$10
  Top 0.406: D31:R41.1 77.96,6.01 D31:C41.1
D31:R31
  Top 0.406: D31:R31.1 77.96,13.11 D31:C31.1
D31:VB+
  Top 0.406: D31:R37.2 74.04,11.3 74.36,10.99 74.36,10.67 | 74.36,10.67 74.36,10.05 D31:R36.1 | D31:C36.1 74.36,10.67
D31:VB-  (via drill 0.4)
  Top 0.406: D31:C46.1 75.73,8.76 D31:R46.2 74.36,8.75 74.36,7.81 74.04,7.49 D31:R47.1 73.83,7.18 v72.45,7.49
  BOTTOM 0.406: D31:R50.2 72.47,7.51 v72.45,7.49
D31:VCOM  (via drill 0.4)
  Top 0.254: D31:U1.2 88.32,8.12 88.33,8.13 88.33,8.45 88.01,8.76 v86.42,9.08
  BOTTOM 0.254: v86.42,9.08 D31:C7.1 85.18,7.19 D31:R1.2
GND  (via drill 0.4, 0.5, 0.6)
  Top 0.254: D0:R38.2 v49.28,208.47 49.28,206.9 D0:R48.1 | D1:R38.2 v96.27,206.19 96.27,204.61 D1:R48.1 | D2:R38.2 v49.28,197.04 49.28,195.47 D2:R48.1 | D3:R38.2 v96.27,194.25 96.27,192.67 D3:R48.1 | D4:R38.2 v49.28,181.8 49.28,180.23 D4:R48.1 | D5:R38.2 v96.27,179.26 96.27,177.69 D5:R48.1 | D6:R38.2 v49.28,169.1 49.28,167.53 D6:R48.1 | D7:R38.2 v96.27,167.83 96.27,166.26 D7:R48.1 | D8:R38.2 v49.28,156.4 49.28,154.83 D8:R48.1 | D9:R38.2 v96.27,155.13 96.27,153.56 D9:R48.1 | D10:R38.2 v51.82,143.06 51.82,141.49 D10:R48.1 | D11:R38.2 v96.27,142.43 96.27,140.86 D11:R48.1 | D13:R38.2 v49.28,131 49.28,129.43 D13:R48.1 | D12:R38.2 v96.27,132.27 96.27,130.7 D12:R48.1 | D15:R38.2 v49.28,118.3 49.28,116.73 D15:R48.1 | D14:R38.2 v96.27,117.03 96.27,115.46 D14:R48.1 | D16:R38.2 v49.28,101.79 49.28,100.22 D16:R48.1 | D17:R38.2 v85.47,98.87 85.47,97.3 D17:R48.1 | D18:R38.2 v49.28,90.61 49.28,89.04 D18:R48.1 | D19:R38.2 v85.47,87.44 85.47,85.87 D19:R48.1 | D20:R38.2 v50.55,75.12 50.55,73.55 D20:R48.1 | D21:R38.2 v92.46,72.58 92.46,71.01 D21:R48.1 | D22:R38.2 v49.28,63.69 49.28,62.12 D22:R48.1 | D23:R38.2 v96.27,61.15 96.27,59.58 D23:R48.1 | D24:R38.2 v49.28,48.45 49.28,46.88 D24:R48.1 | D25:R38.2 v96.27,46.42 96.27,44.85 D25:R48.1 | D26:R38.2 v49.28,37.02 49.28,35.45 D26:R48.1 | D27:R38.2 v96.27,34.99 96.27,33.42 D27:R48.1 | D28:R38.2 v49.91,23.69 49.91,22.11 D28:R48.1 | D29:R38.2 v96.27,20.77 96.27,19.19 D29:R48.1 | D30:R38.2 v49.91,12.26 49.91,10.68 D30:R48.1 | D31:R38.2 v96.27,9.08 96.27,7.51 D31:R48.1 | U5.2 119.38,201.68 v119.63,202.56 | C20.2 v120.27,195.58 | U20.5 U20.4 | U13.2 122.17,78.99 v122.05,78.61
  Top 0.254: U3.13 112.53,7.74 112.65,7.62 v113.28,7.62 | U3.14 113.03,7.87 v113.28,7.62 | U3.15 113.53,7.87 v113.28,7.62 | U3.16 114.03,7.74 113.92,7.62 v113.28,7.62 | C5.2 119.08,8.85 | 119.08,8.85 119.76,8.75 C8.2 | R19.2 v119.25,7.37 119.08,8.85 | R15.2 v113.28,7.62 | v19.94,30.99 19.94,29.69 U11.10
  Top 0.305: R5.1 v12.32,186.69 C1.2 | U1.10 20.83,191.26 v21.21,191.77 | R11.1 54.86,186.69 v54.48,187.83 55.5,188.59 C2.2 | U2.10 v65.91,190.63 | C17.+ 115.82,120.02 116.46,120.02 v117.73,118.75 | R52.1 v121.54,130.18 | U14.7 123.7,125.22 123.44,125.73 v122.81,125.73 | R54.1 v129.16,126.36 U14.6 | U4.2 C6.2 v112.01,81.28 | U17.2 v125.09,71.12 123.46,71.12 R57.2 | C25.2 v132.33,70.1 | v57.4,150.5 56.77,149.86 16.76,149.86 v15.49,151.13 | C9.2 12.45,140.84 v11.68,141.6 | X1.B7 9.16,144.78 R22.1 | R29.1 11.67,77.45 v12.32,78.11 12.57,78.36 C11.2 | C12.2 54.86,75.56 v54.23,74.93 54.85,74.28 R36.1 | U10.10 63.88,76.71 v63.75,76.83 | v11.68,30.99 12.3,30.37 C13.2 12.32,28.84 R41.1 | C14.2 v55.5,23.5 55.48,23.48 R44.1 | U12.10 65.15,25.27 v65.02,25.4 | U6.10 20.7,140.46 v21.21,140.97 | v21.21,79.38 21.21,78.59 U9.10 | C10.2 v57.4,142.24 R25.1 | U7.10 v66.93,142.88 | v122.05,78.61 122.17,77.47 C19.2 | R1.1 108.97,117.35 107.95,117.35 106.43,115.82
  Top 0.406: D0:R46.1 v24.83,208.15 | D0:C46.2 30.76,209.11 | 30.76,209.11 D0:C36.2 | D0:C42.1 34.67,209.11 | 34.67,209.11 D0:C32.1 | 34.67,209.11 v32.45,209.11 30.76,209.11 | D1:R46.1 v71.82,205.87 | D1:C46.2 77.75,206.82 | 77.75,206.82 D1:C36.2 | D1:C42.1 81.66,206.82 | 81.66,206.82 D1:C32.1 | 81.66,206.82 v79.44,206.82 77.75,206.82 | D2:R46.1 v24.83,196.72 | D2:C46.2 30.76,197.68 | 30.76,197.68 D2:C36.2 | D2:C42.1 34.67,197.68 | 34.67,197.68 D2:C32.1 | 34.67,197.68 v32.45,197.68 30.76,197.68 | D3:R46.1 v71.82,193.93 | D3:C46.2 77.75,194.88 | 77.75,194.88 D3:C36.2 | D3:C42.1 81.66,194.88 | 81.66,194.88 D3:C32.1 | 81.66,194.88 v79.44,194.88 77.75,194.88 | D4:R46.1 v24.83,181.48 | D4:C46.2 30.76,182.44 | 30.76,182.44 D4:C36.2 | D4:C42.1 34.67,182.44 | 34.67,182.44 D4:C32.1 | 34.67,182.44 v32.45,182.44 30.76,182.44 | D5:R46.1 v71.82,178.94 | D5:C46.2 77.75,179.9 | 77.75,179.9 D5:C36.2 | D5:C42.1 81.66,179.9 | 81.66,179.9 D5:C32.1 | 81.66,179.9 v79.44,179.9 77.75,179.9 | D6:R46.1 v24.83,168.78 | D6:C46.2 30.76,169.74 | 30.76,169.74 D6:C36.2 | D6:C42.1 34.67,169.74 | 34.67,169.74 D6:C32.1 | 34.67,169.74 v32.45,169.74 30.76,169.74 | D7:R46.1 v71.82,167.51 | D7:C46.2 77.75,168.47 | 77.75,168.47 D7:C36.2 | D7:C42.1 81.66,168.47 | 81.66,168.47 D7:C32.1 | 81.66,168.47 v79.44,168.47 77.75,168.47 | D8:R46.1 v24.83,156.08 | D8:C46.2 30.76,157.04 | 30.76,157.04 D8:C36.2 | D8:C42.1 34.67,157.04 | 34.67,157.04 D8:C32.1 | 34.67,157.04 v32.45,157.04 30.76,157.04 | D9:R46.1 v71.82,154.81 | D9:C46.2 77.75,155.77 | 77.75,155.77 D9:C36.2 | D9:C42.1 81.66,155.77 | 81.66,155.77 D9:C32.1 | 81.66,155.77 v79.44,155.77 77.75,155.77 | D10:R46.1 v27.37,142.75 | D10:C46.2 33.3,143.7 | 33.3,143.7 D10:C36.2
  Top 0.406: D10:C42.1 37.21,143.7 | 37.21,143.7 D10:C32.1 | 37.21,143.7 v34.99,143.7 33.3,143.7 | D11:R46.1 v71.82,142.11 | D11:C46.2 77.75,143.06 | 77.75,143.06 D11:C36.2 | D11:C42.1 81.66,143.06 | 81.66,143.06 D11:C32.1 | 81.66,143.06 v79.44,143.06 77.75,143.06 | D13:R46.1 v24.83,130.68 | D13:C46.2 30.76,131.64 | 30.76,131.64 D13:C36.2 | D13:C42.1 34.67,131.64 | 34.67,131.64 D13:C32.1 | 34.67,131.64 v32.45,131.64 30.76,131.64 | D12:R46.1 v71.82,131.95 | D12:C46.2 77.75,132.91 | 77.75,132.91 D12:C36.2 | D12:C42.1 81.66,132.91 | 81.66,132.91 D12:C32.1 | 81.66,132.91 v79.44,132.91 77.75,132.91 | D15:R46.1 v24.83,117.98 | D15:C46.2 30.76,118.94 | 30.76,118.94 D15:C36.2 | D15:C42.1 34.67,118.94 | 34.67,118.94 D15:C32.1 | 34.67,118.94 v32.45,118.94 30.76,118.94 | D14:R46.1 v71.82,116.71 | D14:C46.2 77.75,117.67 | 77.75,117.67 D14:C36.2 | D14:C42.1 81.66,117.67 | 81.66,117.67 D14:C32.1 | 81.66,117.67 v79.44,117.67 77.75,117.67 | D16:R46.1 v24.83,101.47 | D16:C46.2 30.76,102.42 | 30.76,102.42 D16:C36.2 | D16:C42.1 34.67,102.42 | 34.67,102.42 D16:C32.1 | 34.67,102.42 v32.45,102.42 30.76,102.42 | D17:R46.1 v61.02,98.55 | D17:C46.2 66.95,99.5 | 66.95,99.5 D17:C36.2 | D17:C42.1 70.87,99.5 | 70.87,99.5 D17:C32.1 | 70.87,99.5 v68.64,99.5 66.95,99.5 | D18:R46.1 v24.83,90.3 | D18:C46.2 30.76,91.25 | 30.76,91.25 D18:C36.2 | D18:C42.1 34.67,91.25 | 34.67,91.25 D18:C32.1 | 34.67,91.25 v32.45,91.25 30.76,91.25 | D19:R46.1 v61.02,87.12 | D19:C46.2 66.95,88.08 | 66.95,88.08 D19:C36.2 | D19:C42.1 70.87,88.08 | 70.87,88.08 D19:C32.1 | 70.87,88.08 v68.64,88.08 66.95,88.08 | D20:R46.1 v26.1,74.8 | D20:C46.2 32.03,75.75 | 32.03,75.75 D20:C36.2 | D20:C42.1 35.94,75.75 | 35.94,75.75 D20:C32.1 | 35.94,75.75 v33.72,75.75 32.03,75.75
  Top 0.406: D21:R46.1 v68.01,72.26 | D21:C46.2 73.94,73.22 | 73.94,73.22 D21:C36.2 | D21:C42.1 77.85,73.22 | 77.85,73.22 D21:C32.1 | 77.85,73.22 v75.63,73.22 73.94,73.22 | D22:R46.1 v24.83,63.37 | D22:C46.2 30.76,64.33 | 30.76,64.33 D22:C36.2 | D22:C42.1 34.67,64.33 | 34.67,64.33 D22:C32.1 | 34.67,64.33 v32.45,64.33 30.76,64.33 | D23:R46.1 v71.82,60.83 | D23:C46.2 77.75,61.78 | 77.75,61.78 D23:C36.2 | D23:C42.1 81.66,61.78 | 81.66,61.78 D23:C32.1 | 81.66,61.78 v79.44,61.78 77.75,61.78 | D24:R46.1 v24.83,48.13 | D24:C46.2 30.76,49.09 | 30.76,49.09 D24:C36.2 | D24:C42.1 34.67,49.09 | 34.67,49.09 D24:C32.1 | 34.67,49.09 v32.45,49.09 30.76,49.09 | D25:R46.1 v71.82,46.1 | D25:C46.2 77.75,47.05 | 77.75,47.05 D25:C36.2 | D25:C42.1 81.66,47.05 | 81.66,47.05 D25:C32.1 | 81.66,47.05 v79.44,47.05 77.75,47.05 | D26:R46.1 v24.83,36.7 | D26:C46.2 30.76,37.66 | 30.76,37.66 D26:C36.2 | D26:C42.1 34.67,37.66 | 34.67,37.66 D26:C32.1 | 34.67,37.66 v32.45,37.66 30.76,37.66 | D27:R46.1 v71.82,34.67 | D27:C46.2 77.75,35.62 | 77.75,35.62 D27:C36.2 | D27:C42.1 81.66,35.62 | 81.66,35.62 D27:C32.1 | 81.66,35.62 v79.44,35.62 77.75,35.62 | D28:R46.1 v25.46,23.37 | D28:C46.2 31.39,24.32 | 31.39,24.32 D28:C36.2 | D28:C42.1 35.31,24.32 | 35.31,24.32 D28:C32.1 | 35.31,24.32 v33.08,24.32 31.39,24.32 | D29:R46.1 v71.82,20.45 | D29:C46.2 77.75,21.4 | 77.75,21.4 D29:C36.2 | D29:C42.1 81.66,21.4 | 81.66,21.4 D29:C32.1 | 81.66,21.4 v79.44,21.4 77.75,21.4 | D30:R46.1 v25.46,11.94 | D30:C46.2 31.39,12.89 | 31.39,12.89 D30:C36.2 | D30:C42.1 35.31,12.89 | 35.31,12.89 D30:C32.1 | 35.31,12.89 v33.08,12.89 31.39,12.89 | D31:R46.1 v71.82,8.76 | D31:C46.2 77.75,9.72 | 77.75,9.72 D31:C36.2 | D31:C42.1 81.66,9.72 | 81.66,9.72 D31:C32.1
  Top 0.406: 81.66,9.72 v79.44,9.72 77.75,9.72 | C37.2 117.09,15.88 117.73,16.51 T2.TP | U19.2 121.03,192.41 121.54,191.9 v121.54,191.13 v121.52,191.12 C26.2 | C24.2 v112.65,191.77 | R59.2 v125.98,192.41 | C27.2 113.9,7 v113.28,7.62 | C23.2 121.54,89.53 v120.9,90.17 | C22.2 v122.17,206.38 | C28.1 128.45,115.49 v128.37,115.57
  Top 0.61: C15.1 118.62,119.63 v117.73,118.75
  Top 0.813: C16.- v111.38,93.98 | C18.- 103.15,106.45 103.38,106.68
  Top 1.016: 132.97,122.56 C21.+ v134.87,122.56 | C4.- v136.14,104.78
  Route2 0.61: v129.16,126.36 127.89,125.09 124.08,125.09 123.44,125.73 v122.81,125.73
  BOTTOM 0.406: v24.83,208.15 25.15,208.79 | v71.82,205.87 72.14,206.5 | v24.83,196.72 25.15,197.36 | v71.82,193.93 72.14,194.56 | v24.83,181.48 25.15,182.12 | v71.82,178.94 72.14,179.58 | v24.83,168.78 25.15,169.42 | v71.82,167.51 72.14,168.15 | v24.83,156.08 25.15,156.72 | v71.82,154.81 72.14,155.45 | v27.37,142.75 27.69,143.38 | v71.82,142.11 72.14,142.75 | v24.83,130.68 25.15,131.32 | v71.82,131.95 72.14,132.59 | v24.83,117.98 25.15,118.62 | v71.82,116.71 72.14,117.35 | v24.83,101.47 25.15,102.11 | v61.02,98.55 61.34,99.19 | v24.83,90.3 25.15,90.93 | v61.02,87.12 61.34,87.76 | v26.1,74.8 26.42,75.44 | v68.01,72.26 68.33,72.9 | v24.83,63.37 25.15,64.01 | v71.82,60.83 72.14,61.47 | v24.83,48.13 25.15,48.77 | v71.82,46.1 72.14,46.74 | v24.83,36.7 25.15,37.34 | v71.82,34.67 72.14,35.31 | v25.46,23.37 25.78,24 | v71.82,20.45 72.14,21.08 | v25.46,11.94 25.78,12.57 | v71.82,8.76 72.14,9.4
  other vias: 106.3,108.58 105.66,102.23 115.82,103.5 124.71,109.22 124.71,114.94 122.81,114.94 115.82,114.94 104.39,114.94 104.39,104.14 106.3,104.78 120.9,98.42 122.81,98.42 122.81,92.71 120.9,92.71 122.81,90.17 115.19,111.76 125.35,97.79 124.71,94.61 125.98,90.81 129.16,90.81 131.06,90.17 133.6,98.42 131.06,99.06 113.28,10.16 115.19,108.58 110.34,109.78 111.99,101.6
  pour BOTTOM: 24.51,213.23 24.51,204.34 49.91,204.34 49.91,213.23
  pour BOTTOM: 71.5,210.95 71.5,202.06 96.9,202.06 96.9,210.95
  pour BOTTOM: 24.51,201.8 24.51,192.91 49.91,192.91 49.91,201.8
  pour BOTTOM: 71.5,199.01 71.5,190.12 96.9,190.12 96.9,199.01
  pour BOTTOM: 24.51,186.56 24.51,177.67 49.91,177.67 49.91,186.56
  pour BOTTOM: 71.5,184.02 71.5,175.13 96.9,175.13 96.9,184.02
  pour BOTTOM: 24.51,173.86 24.51,164.97 49.91,164.97 49.91,173.86
  pour BOTTOM: 71.5,172.59 71.5,163.7 96.9,163.7 96.9,172.59
  pour BOTTOM: 24.51,161.16 24.51,152.27 49.91,152.27 49.91,161.16
  pour BOTTOM: 71.5,159.89 71.5,151 96.9,151 96.9,159.89
  pour BOTTOM: 27.05,147.83 27.05,138.94 52.45,138.94 52.45,147.83
  pour BOTTOM: 71.5,147.19 71.5,138.3 96.9,138.3 96.9,147.19
  pour BOTTOM: 24.51,135.76 24.51,126.87 49.91,126.87 49.91,135.76
  pour BOTTOM: 71.5,137.03 71.5,128.14 96.9,128.14 96.9,137.03
  pour BOTTOM: 24.51,123.06 24.51,114.17 49.91,114.17 49.91,123.06
  pour BOTTOM: 71.5,121.79 71.5,112.9 96.9,112.9 96.9,121.79
  pour BOTTOM: 24.51,106.55 24.51,97.66 49.91,97.66 49.91,106.55
  pour BOTTOM: 60.71,103.63 60.71,94.74 86.11,94.74 86.11,103.63
  pour BOTTOM: 24.51,95.38 24.51,86.49 49.91,86.49 49.91,95.38
  pour BOTTOM: 60.71,92.2 60.71,83.31 86.11,83.31 86.11,92.2
  pour BOTTOM: 25.78,79.88 25.78,70.99 51.18,70.99 51.18,79.88
  pour BOTTOM: 67.69,77.34 67.69,68.45 93.09,68.45 93.09,77.34
  pour BOTTOM: 24.51,68.45 24.51,59.56 49.91,59.56 49.91,68.45
  pour BOTTOM: 71.5,65.91 71.5,57.02 96.9,57.02 96.9,65.91
  pour BOTTOM: 24.51,53.21 24.51,44.32 49.91,44.32 49.91,53.21
  pour BOTTOM: 71.5,51.18 71.5,42.29 96.9,42.29 96.9,51.18
  pour BOTTOM: 24.51,41.78 24.51,32.89 49.91,32.89 49.91,41.78
  pour BOTTOM: 71.5,39.75 71.5,30.86 96.9,30.86 96.9,39.75
  pour BOTTOM: 25.15,28.45 25.15,19.56 50.55,19.56 50.55,28.45
  pour BOTTOM: 71.5,25.53 71.5,16.64 96.9,16.64 96.9,25.53
  pour BOTTOM: 25.15,17.02 25.15,8.13 50.55,8.13 50.55,17.02
  pour BOTTOM: 71.5,13.84 71.5,4.95 96.9,4.95 96.9,13.84
  pour Top (rank 3, no thermals): 110.11,116.2 113.92,116.2 113.77,100.56 109.93,100.63
  pour Top: 118.36,116.2 125.98,116.2 125.98,102.23 118.36,102.23
  pour Top (rank 3, no thermals): 103.12,116.2 110.11,116.2 110.36,100.58 103.12,100.58
  pour Top (no thermals): 119.63,99.69 127.25,99.69 127.25,88.9 119.63,88.9
  pour Top: 127.25,99.69 135.51,99.69 135.51,88.9 127.25,88.9
  pour Top (rank 3, no thermals): 113.92,116.2 118.36,116.2 118.36,102.23 113.92,102.23
  pour BOTTOM (no thermals): 113.92,116.2 118.36,116.2 118.36,102.23 113.92,102.23
  pour BOTTOM (no thermals): 119.63,99.69 127.25,99.69 127.25,88.9 119.63,88.9
  pour BOTTOM (rank 3): 2.79,217.81 145.67,217.81 146.94,216.53 146.94,2.54 147.57,1.91 2.79,1.91
  pour BOTTOM (no thermals): 123.42,100.71 102.97,100.71 102.97,116.23 126.03,116.23 126.03,116.03 126.11,116.03 126.11,104.57
  pour Top (rank 2): 107.44,109.22 111,109.22 111,107.19 107.44,107.19
GPIO2
  BOTTOM 0.305: GPIO2.TP X3.C26
HVIN
  Top 0.254: U3.4 114.55,11.04 114.55,11.43 114.42,11.56 U3.5 114.03,12.18 114.55,12.7 | 114.55,12.7 114.55,14.29 R17.1 114.55,14.92 114.55,16.51 111.38,16.51 111.06,16.19 R9.2 | R8.1 122.49,13.02 HVIN.TP 120.9,12.06 119.63,13.34 117.46,13.34 C37.1 116.09,12.97 115.82,12.7 114.55,12.7
I2CEN  (via drill 0.6)
  Top 0.254: X3.A26 143.13,194.31 140.97,194.31 140.46,194.82 140.46,196.09 139.95,196.6 139.45,196.85 134.87,196.85 133.6,195.58 R46.1 131.06,195.56 131.06,194.31 127.89,194.31 v127.25,194.94 | U5.6 119.89,204.72 120.27,205.1 v123.44,205.1 | U13.6 122.81,84.45 124.08,85.09 125.35,85.09
  Top 0.305: v127.25,136.53 v136.14,136.53 | v133.6,86.36 132.97,85.09 125.35,85.09
  Route3 0.254: v127.25,194.94 123.44,196.22 v123.44,205.1
  Route3 0.305: v127.25,194.94 v127.25,136.53 | v136.14,136.53 137.41,132.08 137.41,115.57 134.87,107.95 134.87,94.61 133.6,92.08 v133.6,86.36
IN0
  Top 0.406: D0:C41.2 28.96,205.61 28.32,204.98 27.15,204.98 D0:R47.2 26.95,204.98 26.42,204.98 25.91,205.49 25.91,205.74 25.65,205.99 24.64,205.99 23.62,207.01 6.6,207.01 X1.A32
IN1
  Top 0.305: X1.A30 6.6,201.93 8.51,201.93 9.78,203.2 70.74,203.2 71.12,203.58 72.75,203.58 D1:R47.2
  Top 0.406: D1:C41.2 75.95,203.33 75.31,202.69 74.14,202.69 D1:R47.2
IN2
  Top 0.305: X1.A28 6.6,196.85 22.48,196.85 25.02,194.31 25.91,194.31 26.16,194.06 26.65,194.06 D2:R47.2
  Top 0.406: D2:C41.2 28.96,194.18 28.32,193.55 27.15,193.55 D2:R47.2
IN3
  Top 0.305: D3:R47.2 73.56,190.86 72.64,191.77 70.74,191.77 70.1,192.41 70.1,193.68 69.47,194.31 59.31,194.31 56.13,191.13 23.11,191.13 21.84,192.41 21.84,193.68 21.21,194.31 10.41,194.31 9.78,193.68 9.78,193.04 8.51,191.77 6.6,191.77 X1.A26
  Top 0.406: D3:C41.2 75.95,191.39 75.31,190.75 74.14,190.75 D3:R47.2
IN4
  Top 0.305: X1.A24 6.6,186.69 9.78,186.69 12.32,184.15 23.11,184.15 23.75,179.71 24.38,178.44 26.39,178.44 D4:R47.2
  Top 0.406: D4:C41.2 28.96,178.94 28.32,178.31 27.15,178.31 D4:R47.2
IN5
  Top 0.305: X1.A22 6.6,181.61 11.05,181.61 17.4,175.26 68.2,175.26 69.47,176.53 73.38,176.53 D5:R47.2
  Top 0.406: D5:C41.2 75.95,176.4 75.31,175.77 74.14,175.77 D5:R47.2
IN6
  Top 0.305: X1.A20 6.6,176.53 11.05,176.53 14.86,172.72 21.84,172.72 23.11,171.45 23.11,168.28 25.65,165.74 27.03,165.74 D6:R47.2
  Top 0.406: D6:C41.2 28.96,166.24 28.32,165.61 27.15,165.61 D6:R47.2
IN7
  Top 0.305: X1.A18 6.6,171.45 11.05,171.45 18.03,163.19 68.2,163.19 70.36,165.35 72.9,165.35 73.15,165.1 73.28,165.1 73.94,164.44 D7:R47.2
  Top 0.406: D7:C41.2 75.95,164.97 75.31,164.34 74.14,164.34 D7:R47.2
IN8
  Top 0.305: X1.A16 6.6,166.37 11.05,166.37 23.11,153.67 25.65,153.67 26.16,153.16 27.3,153.16 27.56,152.91
  Top 0.406: D8:C41.2 28.96,153.54 28.32,152.91 27.56,152.91 27.15,152.91 D8:R47.2
IN9
  Top 0.305: X1.A14 6.6,161.29 12.32,161.29 14.86,158.75 14.86,155.57 21.21,150.5 55.5,150.5 57.4,156.84 69.09,156.84 70.74,153.67 70.99,153.03 73.41,151.89 73.89,151.89 D9:R47.2
  Top 0.406: D9:C41.2 75.95,152.27 75.31,151.64 74.14,151.64 D9:R47.2
IN10
  Top 0.305: X1.A12 6.6,156.21 9.14,156.21 10.41,154.94 10.41,148.59 15.49,146.69 25.65,146.69 26.29,146.05 26.29,140.97 26.92,140.34 28.45,140.34 28.96,139.83 29.44,139.83 D10:R47.2
  Top 0.406: D10:C41.2 31.5,140.21 30.86,139.57 29.69,139.57 D10:R47.2
IN11  (via drill 0.6)
  Top 0.305: v12.95,150.5 14.86,148.59 66.29,148.59 70.74,144.78 70.74,140.34 71.12,139.95 71.25,139.95 71.5,139.7 73.15,139.7 73.81,139.04 D11:R47.2
  Top 0.406: D11:C41.2 75.95,139.57 75.31,138.94 74.14,138.94 D11:R47.2
  Route2 0.305: X1.A10 6.6,151.13 9.14,151.13 9.78,150.5 v12.95,150.5
IN12
  Top 0.305: X1.A8 5.33,146.69 5.97,146.05 9.78,146.05 12.32,144.15 23.11,144.15 24.38,142.88 24.38,138.43 25.65,137.16 56.13,137.16 57.4,135.89 69.47,135.89 70.1,135.25 70.1,130.81 72.01,128.91 74.02,128.91 D12:R47.2 75.52,128.88 D12:C41.2
IN13
  Top 0.305: D13:C41.2 28.7,128.14 28.19,127.64 27.08,127.64 | 27.08,127.64 D13:R47.2 | X1.A6 6.6,140.97 6.6,139.06 7.24,138.43 9.78,138.43 14.22,133.99 21.84,133.99 22.48,133.35 22.48,130.18 25.02,127.64 27.08,127.64
IN14
  Top 0.305: X1.A4 6.6,135.89 6.6,133.99 7.24,133.35 11.05,133.35 14.86,129.54 17.4,129.54 22.48,124.46 65.02,124.46 68.83,116.84 72.01,113.67 74.02,113.67 D14:R47.2 75.52,113.64 D14:C41.2
IN15
  Top 0.305: X1.A2 5.97,132.08 7.24,130.81 11.05,130.81 20.57,121.28 22.48,121.28 23.11,120.65 23.11,116.2 24.77,116.2 26.16,114.81 26.95,114.81 D15:R47.2 28.53,114.91 D15:C41.2
IN16
  Top 0.305: X2.A32 6.6,88.9 9.78,88.9 12.32,91.44 12.32,97.16 13.59,98.42 26.29,98.42 D16:R47.2
  Top 0.406: D16:C41.2 28.96,98.93 28.32,98.3 27.15,98.3 D16:R47.2
IN17
  Top 0.305: X2.A30 6.6,83.82 8.51,83.82 9.78,85.09 9.78,86.36 14.22,91.44 14.22,94.61 16.13,96.39 58.67,96.39 61.09,95.38 D17:R47.2
  Top 0.406: D17:C41.2 65.15,96.01 64.52,95.38 63.35,95.38 D17:R47.2
IN18
  Top 0.305: D18:R47.2 26.29,87.63 14.22,87.63 11.68,85.09 11.05,83.19 9.53,80.14 8.51,78.74 5.97,78.74 X2.A28
  Top 0.406: D18:C41.2 28.96,87.76 28.32,87.12 27.15,87.12 D18:R47.2
IN19
  Top 0.305: X2.A26 5.97,73.66 8.51,73.66 14.22,84.45 52.32,84.45 54.86,87 58.67,87 61.21,84.45 62.84,84.45 D19:R47.2
  Top 0.406: D19:C41.2 65.15,84.58 64.52,83.95 63.35,83.95 D19:R47.2
IN20
  Top 0.305: X2.A24 5.97,68.58 9.14,68.58 12.95,72.39 26.92,72.39 27.56,71.75 D20:R47.2
  Top 0.406: D20:C41.2 30.23,72.26 29.59,71.63 28.42,71.63 D20:R47.2
IN21
  Top 0.305: X2.A22 6.6,63.5 9.14,63.5 14.86,69.22 45.34,69.22 45.97,69.22 65.66,69.22 66.93,67.94 69.47,67.94 70.23,68.71 D21:R47.2
  Top 0.406: D21:C41.2 72.14,69.72 71.5,69.09 70.33,69.09 D21:R47.2
IN22
  Top 0.305: X2.A20 5.97,58.42 9.14,58.42 11.68,60.96 25.65,60.96 D22:R47.2
  Top 0.406: D22:C41.2 28.96,60.83 28.32,60.2 27.15,60.2 D22:R47.2
IN23
  Top 0.305: X2.A18 6.6,53.34 9.78,53.34 13.59,57.78 74.42,57.78 74.55,57.66
  Top 0.406: D23:C41.2 75.95,58.29 75.31,57.66 74.55,57.66 74.14,57.66 D23:R47.2
IN24
  Top 0.305: X2.A16 6.6,48.26 22.48,48.26 23.75,45.72 26.29,45.72 27.56,44.96
  Top 0.406: D24:C41.2 28.96,45.59 28.32,44.96 27.56,44.96 27.15,44.96 D24:R47.2
IN25
  Top 0.305: X2.A14 6.6,43.18 56.77,43.18 59.94,46.35 69.47,46.35 72.01,43.81 72.64,43.81 73.28,43.18 73.89,43.18 D25:R47.2
  Top 0.406: D25:C41.2 75.95,43.56 75.31,42.93 74.14,42.93 D25:R47.2
IN26
  Top 0.305: X2.A12 6.6,38.1 22.48,38.1 23.75,36.83 23.75,34.92 24.38,34.29 25.65,34.29 D26:R47.2
  Top 0.406: D26:C41.2 28.96,34.16 28.32,33.53 27.15,33.53 D26:R47.2
IN27
  Top 0.305: D27:R47.2 72.16,31.6 70.74,33.02 54.86,33.02 52.32,30.48 23.75,30.48 21.21,33.02 21.21,34.29 20.57,34.92 10.41,34.92 8.51,33.02 5.97,33.02 5.33,33.66 X2.A10
  Top 0.406: D27:C41.2 75.95,32.13 75.31,31.5 74.14,31.5 D27:R47.2
IN28
  Top 0.305: X2.A8 6.6,27.94 9.14,27.94 9.78,27.3 9.78,24.13 10.41,23.5 23.11,23.5 25.02,20.95 26.39,20.95 D28:R47.2
  Top 0.406: D28:C41.2 29.59,20.83 28.96,20.19 27.79,20.19 D28:R47.2
IN29
  Top 0.305: X2.A6 6.6,22.86 8.51,22.86 14.86,17.78 68.2,17.78 69.47,17.14 73.81,17.14 D29:R47.2
  Top 0.406: D29:C41.2 75.95,17.91 75.31,17.27 74.14,17.27 D29:R47.2
IN30
  Top 0.305: X2.A4 6.6,17.78 9.78,17.78 16.13,13.34 23.11,13.34 25.02,10.16 25.65,10.16 26.29,9.53 26.67,9.53 26.67,9.4 27.05,9.02 27.53,9.02 D30:R47.2
  Top 0.406: D30:C41.2 29.59,9.4 28.96,8.76 27.79,8.76 D30:R47.2
IN31
  Top 0.305: X2.A2 6.6,12.7 10.41,12.7 16.76,6.35 59.31,6.35 60.58,7.62 70.74,7.62 71.37,6.35 72.01,6.35 73.28,5.71 74.02,5.71 D31:R47.2
  Top 0.406: D31:C41.2 75.95,6.22 75.31,5.59 74.14,5.59 D31:R47.2
IP0
  Top 0.254: D0:C31.2 27.27,212.28 D0:R37.1
  Top 0.406: X1.B32 21.84,208.28 21.84,210.82 23.11,212.09 26.65,212.09 D0:R37.1
IP1
  Top 0.254: D1:C31.2 74.26,209.99 D1:R37.1
  Top 0.305: D1:R37.1 71.4,210.21 68.83,207.65 68.83,205.1 67.56,203.84 8.51,203.84 X1.B30
IP2
  Top 0.254: D2:C31.2 27.27,200.85 D2:R37.1
  Top 0.305: X1.B28 22.61,198.12 25.15,200.66 26.65,200.66 D2:R37.1
IP3
  Top 0.254: D3:C31.2 74.55,198.06 74.26,198.06 D3:R37.1
  Top 0.305: X1.B26 9.78,194.94 21.84,194.94 22.48,194.31 22.48,192.66 23.37,191.77 55.5,191.77 58.67,194.94 69.47,194.94 69.47,195.58 72.01,198.12 73.89,198.12 D3:R37.1 | 74.48,198.12 74.55,198.06
IP4
  Top 0.254: D4:C31.2 27.27,185.61 D4:R37.1
  Top 0.305: X1.B24 9.14,187.96 12.95,184.78 23.75,184.78 25.02,186.06 26.82,186.06 D4:R37.1
IP5
  Top 0.254: D5:C31.2 74.55,183.07 74.26,183.07 D5:R37.1
  Top 0.305: X1.B22 11.05,182.88 18.03,175.9 67.56,175.9 68.83,177.16 68.83,182.25 70.1,183.51 74.1,183.51 74.55,183.07
IP6
  Top 0.254: D6:C31.2 27.27,172.91 D6:R37.1
  Top 0.305: X1.B20 11.05,177.8 15.49,173.35 26.82,173.35 D6:R37.1
IP7
  Top 0.254: D7:C31.2 74.26,171.64 D7:R37.1
  Top 0.305: X1.B18 8.51,172.72 9.14,172.09 11.68,172.09 18.67,163.83 66.93,163.83 70.1,167 70.1,170.81 70.74,171.45 73.64,171.45 D7:R37.1
IP8
  Top 0.254: D8:C31.2 27.27,160.21 D8:R37.1
  Top 0.305: X1.B16 11.05,167.64 19.94,158.12 22.48,158.12 24.38,160.02 26.65,160.02 D8:R37.1
IP9
  Top 0.254: D9:C31.2 74.26,158.94 D9:R37.1
  Top 0.305: X1.B14 8.51,162.56 9.14,161.93 12.95,161.93 15.49,159.38 15.49,156.21 21.84,151.13 54.86,151.13 56.77,157.48 70.74,157.48 72.01,159.38 73.81,159.38 D9:R37.1
IP10
  Top 0.254: D10:C31.2 29.81,146.88 D10:R37.1
  Top 0.305: X1.B12 10.41,157.48 11.05,154.94 11.05,149.22 15.49,147.32 29.36,147.32 D10:R37.1
IP11  (via drill 0.6)
  Top 0.254: D11:C31.2 74.26,146.24 D11:R37.1
  Top 0.305: v12.95,152.4 15.49,149.22 66.93,149.22 70.74,146.69 D11:R37.1
  Route2 0.305: X1.B10 v12.95,152.4
IP12
  Top 0.305: X1.B8 9.78,147.32 12.95,144.78 23.75,144.78 25.02,143.51 25.02,139.06 26.29,137.79 56.77,137.79 58.04,136.53 73.81,136.53 D12:R37.1 75.83,136.3 D12:C31.2
IP13
  Top 0.305: X1.B6 7.87,141.6 8.51,140.97 9.14,140.97 9.78,140.34 9.78,139.7 14.86,134.62 25.91,134.62 26.16,134.87 26.9,134.87 D13:R37.1 28.84,135.03 D13:C31.2
IP14
  Top 0.305: X1.B4 8.51,137.16 15.49,130.18 18.03,130.18 23.11,125.09 65.15,125.09 69.09,121.16 73.94,121.16 D14:R37.1 75.83,121.06 D14:C31.2
IP15
  Top 0.305: X1.B2 11.05,132.08 20.57,122.56 26.82,122.56 D15:R37.1 28.84,122.33 D15:C31.2
IP16
  Top 0.254: D16:C31.2 27.27,105.6 D16:R37.1
  Top 0.305: X2.B32 9.78,90.17 11.68,92.08 11.68,97.79 12.95,99.06 21.84,99.06 23.11,100.33 23.11,104.78 23.75,105.79 D16:R37.1 26.92,105.41
IP17
  Top 0.254: D17:C31.2 63.46,102.68 D17:R37.1
  Top 0.305: X2.B30 13.59,91.44 13.59,95.89 14.86,97.03 58.04,97.03 58.67,97.79 58.67,101.6 60.58,102.87 D17:R37.1
IP18
  Top 0.254: D18:C31.2 27.27,94.42 D18:R37.1
  Top 0.305: D18:R37.1 23.11,94.61 22.48,93.34 22.48,88.9 21.84,88.27 13.59,88.27 11.05,85.72 10.41,83.82 9.14,81.28 X2.B28
IP19
  Top 0.254: D19:C31.2 63.75,91.25 63.46,91.25 D19:R37.1
  Top 0.305: X2.B26 8.89,76.45 13.59,85.09 51.69,85.09 54.23,87.63 58.67,87.63 58.67,88.9 61.21,91.44 63.22,91.44 D19:R37.1 | 63.56,91.44 63.75,91.25
IP20
  Top 0.254: D20:C31.2 28.54,78.93 D20:R37.1
  Top 0.305: X2.B24 9.14,69.85 12.32,73.03 22.48,73.03 25.15,73.91 25.15,77.09 26.29,78.74 D20:R37.1
IP21
  Top 0.254: D21:C31.2 70.45,76.39 D21:R37.1
  Top 0.305: X2.B22 9.14,64.77 14.22,69.85 65.02,69.85 66.93,71.75 66.93,75.56 67.56,76.2 69.83,76.2 D21:R37.1
IP22
  Top 0.254: D22:C31.2 27.27,67.5 D22:R37.1
  Top 0.305: X2.B20 9.14,59.69 11.05,61.59 23.11,61.59 23.75,62.23 23.75,66.67 25.02,67.31 D22:R37.1
IP23
  Top 0.254: D23:C31.2 74.26,64.96 D23:R37.1
  Top 0.305: X2.B18 9.78,54.61 12.95,58.42 69.47,58.42 70.1,59.05 70.1,63.5 71.37,64.77 73.64,64.77 D23:R37.1
IP24
  Top 0.254: D24:C31.2 27.27,52.26 D24:R37.1
  Top 0.305: X2.B16 9.14,48.9 22.48,48.9 23.75,50.16 23.75,51.44 24.38,52.07 D24:R37.1
IP25
  Top 0.254: D25:C31.2 74.55,50.23 74.26,50.23 D25:R37.1
  Top 0.305: X2.B14 9.14,43.81 56.13,43.81 59.31,46.99 69.47,46.99 70.74,48.26 70.74,49.53 71.37,50.16 74.48,50.16 74.55,50.23
IP26
  Top 0.254: D26:C31.2 27.27,40.83 D26:R37.1
  Top 0.305: X2.B12 23.11,39.37 24.38,40.64 D26:R37.1
IP27
  Top 0.254: D27:C31.2 74.26,38.8 D27:R37.1
  Top 0.305: D27:R37.1 71.02,39.01 70.1,38.1 70.1,34.29 69.47,33.66 54.23,33.66 51.69,31.11 24.38,31.11 | 21.84,33.66 21.84,34.92 21.21,35.56 9.14,35.56 X2.B10
  Top 0.406: 24.38,31.11 21.84,33.66
IP28
  Top 0.254: D28:C31.2 27.9,27.5 D28:R37.1
  Top 0.305: X2.B8 9.14,29.21 10.41,27.94 10.41,24.77 11.05,24.13 23.11,24.13 25.02,27.3 27.28,27.3 D28:R37.1
IP29
  Top 0.254: D29:C31.2 74.26,24.57 D29:R37.1
  Top 0.305: X2.B6 15.49,18.41 69.47,18.41 70.74,19.68 70.74,23.5 72.01,24.77 74.02,24.77 D29:R37.1
IP30
  Top 0.254: D30:C31.2 27.9,16.07 D30:R37.1
  Top 0.305: X2.B4 9.78,19.05 16.76,13.97 23.75,13.97 25.65,15.88 27.28,15.88 D30:R37.1
IP31
  Top 0.254: D31:C31.2 74.26,12.89 D31:R37.1
  Top 0.305: X2.B2 10.41,13.97 17.4,6.99 58.67,6.99 59.94,8.26 68.83,8.26 70.74,10.16 70.74,12.06 71.37,12.7 73.64,12.7 D31:R37.1
LDAC1
  Top 0.305: U1.4 14.35,189.36 LD1.TP 15.49,187.96 15.49,187.32 15.51,187.31 R5.2
LDAC2
  Top 0.305: R11.2 59.31,186.69 LDAC2.TP 60.71,188.09 U2.4
LDAC3
  Top 0.305: U6.4 14.99,137.92 LDAC3.TP 13.59,139.06 11.68,139.06 R22.2
LDAC4
  Top 0.305: R25.2 LDAC4.TP 61.34,140.46 U7.4
LDAC5
  Top 0.305: U9.4 14.99,76.96 LDAC5.TP 14.22,76.83 13.59,76.2 R29.2
LDAC6
  Top 0.305: R36.2 LDAC6.TP 58.17,74.42 U10.4
LDAC7
  Top 0.305: U11.4 14.35,28.07 LDAC7.TP R41.2
LDAC8