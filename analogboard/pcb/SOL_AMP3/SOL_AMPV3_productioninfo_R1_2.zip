# EAGLE board SOL_AMPV3 (EAGLE 7.6.0), part 2 of 5
## Placement (x,y rotation side) (continued)
D24:C33  27p  [C0402]  39.12,50.99 90 top
D24:C34  nc  [C0402]  45.47,51.31 0 top
D24:C35  10n  [C0402]  44.2,46.23 180 bottom
D24:C36  100n  [C0603]  29.91,50.04 0 top
D24:C41  4.7n  [C0603]  29.91,45.59 180 top
D24:C42  150p  [C0402]  34.67,47.5 270 top
D24:C43  27p  [C0402]  39.12,46.23 270 top
D24:C44  nc  [C0402]  45.47,44.96 0 top
D24:C45  10n  [C0402]  45.47,51.31 180 bottom
D24:C46  100n  [C0603]  29.91,47.82 0 top
D24:R1  1K  [R0402]  37.53,46.55 180 bottom
D24:R31  24.3E  [R0603]  32.77,51.63 270 top
D24:R32  24.3E  [R0603]  36.89,50.04 0 top
D24:R33  2K7  [R0603]  36.89,52.26 0 top
D24:R34  200E  [R0402]  45.47,52.58 0 top
D24:R35  1K4  [R0402]  47.69,51.63 270 top
D24:R36  10K  [R0402]  26.73,49.4 180 top
D24:R37  100K  [R0603]  27.05,51.63 270 top
D24:R38  NC  [R0402]  49.28,50.99 270 top
D24:R39  10E  [R0402]  44.2,47.5 0 bottom
D24:R41  24.3E  [R0603]  32.77,46.23 90 top
D24:R42  24.3E  [R0603]  36.89,47.82 0 top
D24:R43  2K7  [R0603]  36.89,45.59 0 top
D24:R44  200E  [R0402]  45.47,46.23 0 top
D24:R45  1K5  [R0402]  45.47,48.77 180 top
D24:R46  10K  [R0402]  26.73,48.13 0 top
D24:R47  100K  [R0603]  27.05,45.91 270 top
D24:R48  20K  [R0402]  48.96,45.91 270 top
D24:R49  10E  [R0402]  45.47,49.4 0 bottom
D24:R50  470E  [R0402]  27.05,45.91 90 bottom
D24:R51  nc  [R0402]  45.47,50.04 180 top
D24:R61  nc  [R0402]  45.47,47.5 180 top
D24:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  41.66,48.77 90 top
D25:C1  100n  [C0402]  86.11,48.01 180 bottom
D25:C2  10n  [C0402]  86.11,49.28 180 bottom
D25:C3  100n  [C0402]  89.28,48.64 0 bottom
D25:C4  10n  [C0402]  89.28,49.91 0 bottom
D25:C7  10n  [C0402]  86.74,44.2 270 bottom
D25:C31  4.7n  [C0603]  76.9,50.23 180 top
D25:C32  150p  [C0402]  81.66,48.64 90 top
D25:C33  27p  [C0402]  86.11,48.96 90 top
D25:C34  nc  [C0402]  92.46,49.28 0 top
D25:C35  10n  [C0402]  91.19,44.2 180 bottom
D25:C36  100n  [C0603]  76.9,48.01 0 top
D25:C41  4.7n  [C0603]  76.9,43.56 180 top
D25:C42  150p  [C0402]  81.66,45.47 270 top
D25:C43  27p  [C0402]  86.11,44.2 270 top
D25:C44  nc  [C0402]  92.46,42.93 0 top
D25:C45  10n  [C0402]  92.46,49.28 180 bottom
D25:C46  100n  [C0603]  76.9,45.78 0 top
D25:R1  1K  [R0402]  84.52,44.51 180 bottom
D25:R31  24.3E  [R0603]  79.76,49.59 270 top
D25:R32  24.3E  [R0603]  83.88,48.01 0 top
D25:R33  2K7  [R0603]  83.88,50.23 0 top
D25:R34  200E  [R0402]  92.46,50.55 0 top
D25:R35  1K4  [R0402]  94.68,49.59 270 top
D25:R36  10K  [R0402]  73.72,47.37 180 top
D25:R37  100K  [R0603]  74.04,49.59 270 top
D25:R38  NC  [R0402]  96.27,48.96 270 top
D25:R39  10E  [R0402]  91.19,45.47 0 bottom
D25:R41  24.3E  [R0603]  79.76,44.2 90 top
D25:R42  24.3E  [R0603]  83.88,45.78 0 top
D25:R43  2K7  [R0603]  83.88,43.56 0 top
D25:R44  200E  [R0402]  92.46,44.2 0 top
D25:R45  1K5  [R0402]  92.46,46.74 180 top
D25:R46  10K  [R0402]  73.72,46.1 0 top
D25:R47  100K  [R0603]  74.04,43.88 270 top
D25:R48  20K  [R0402]  95.95,43.88 270 top
D25:R49  10E  [R0402]  92.46,47.37 0 bottom
D25:R50  470E  [R0402]  74.04,43.88 90 bottom
D25:R51  nc  [R0402]  92.46,48.01 180 top
D25:R61  nc  [R0402]  92.46,45.47 180 top
D25:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  88.65,46.74 90 top
D26:C1  100n  [C0402]  39.12,38.61 180 bottom
D26:C2  10n  [C0402]  39.12,39.88 180 bottom
D26:C3  100n  [C0402]  42.29,39.24 0 bottom
D26:C4  10n  [C0402]  42.29,40.51 0 bottom
D26:C7  10n  [C0402]  39.75,34.8 270 bottom
D26:C31  4.7n  [C0603]  29.91,40.83 180 top
D26:C32  150p  [C0402]  34.67,39.24 90 top
D26:C33  27p  [C0402]  39.12,39.56 90 top
D26:C34  nc  [C0402]  45.47,39.88 0 top
D26:C35  10n  [C0402]  44.2,34.8 180 bottom
D26:C36  100n  [C0603]  29.91,38.61 0 top
D26:C41  4.7n  [C0603]  29.91,34.16 180 top
D26:C42  150p  [C0402]  34.67,36.07 270 top
D26:C43  27p  [C0402]  39.12,34.8 270 top
D26:C44  nc  [C0402]  45.47,33.53 0 top
D26:C45  10n  [C0402]  45.47,39.88 180 bottom
D26:C46  100n  [C0603]  29.91,36.39 0 top
D26:R1  1K  [R0402]  37.53,35.12 180 bottom
D26:R31  24.3E  [R0603]  32.77,40.2 270 top
D26:R32  24.3E  [R0603]  36.89,38.61 0 top
D26:R33  2K7  [R0603]  36.89,40.83 0 top
D26:R34  200E  [R0402]  45.47,41.15 0 top
D26:R35  1K4  [R0402]  47.69,40.2 270 top
D26:R36  10K  [R0402]  26.73,37.97 180 top
D26:R37  100K  [R0603]  27.05,40.2 270 top
D26:R38  NC  [R0402]  49.28,39.56 270 top
D26:R39  10E  [R0402]  44.2,36.07 0 bottom
D26:R41  24.3E  [R0603]  32.77,34.8 90 top
D26:R42  24.3E  [R0603]  36.89,36.39 0 top
D26:R43  2K7  [R0603]  36.89,34.16 0 top
D26:R44  200E  [R0402]  45.47,34.8 0 top
D26:R45  1K5  [R0402]  45.47,37.34 180 top
D26:R46  10K  [R0402]  26.73,36.7 0 top
D26:R47  100K  [R0603]  27.05,34.48 270 top
D26:R48  20K  [R0402]  48.96,34.48 270 top
D26:R49  10E  [R0402]  45.47,37.97 0 bottom
D26:R50  470E  [R0402]  27.05,34.48 90 bottom
D26:R51  nc  [R0402]  45.47,38.61 180 top
D26:R61  nc  [R0402]  45.47,36.07 180 top
D26:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  41.66,37.34 90 top
D27:C1  100n  [C0402]  86.11,36.58 180 bottom
D27:C2  10n  [C0402]  86.11,37.85 180 bottom
D27:C3  100n  [C0402]  89.28,37.21 0 bottom
D27:C4  10n  [C0402]  89.28,38.48 0 bottom
D27:C7  10n  [C0402]  86.74,32.77 270 bottom
D27:C31  4.7n  [C0603]  76.9,38.8 180 top
D27:C32  150p  [C0402]  81.66,37.21 90 top
D27:C33  27p  [C0402]  86.11,37.53 90 top
D27:C34  nc  [C0402]  92.46,37.85 0 top
D27:C35  10n  [C0402]  91.19,32.77 180 bottom
D27:C36  100n  [C0603]  76.9,36.58 0 top
D27:C41  4.7n  [C0603]  76.9,32.13 180 top
D27:C42  150p  [C0402]  81.66,34.04 270 top
D27:C43  27p  [C0402]  86.11,32.77 270 top
D27:C44  nc  [C0402]  92.46,31.5 0 top
D27:C45  10n  [C0402]  92.46,37.85 180 bottom
D27:C46  100n  [C0603]  76.9,34.35 0 top
D27:R1  1K  [R0402]  84.52,33.08 180 bottom
D27:R31  24.3E  [R0603]  79.76,38.16 270 top
D27:R32  24.3E  [R0603]  83.88,36.58 0 top
D27:R33  2K7  [R0603]  83.88,38.8 0 top
D27:R34  200E  [R0402]  92.46,39.12 0 top
D27:R35  1K4  [R0402]  94.68,38.16 270 top
D27:R36  10K  [R0402]  73.72,35.94 180 top
D27:R37  100K  [R0603]  74.04,38.16 270 top
D27:R38  NC  [R0402]  96.27,37.53 270 top
D27:R39  10E  [R0402]  91.19,34.04 0 bottom
D27:R41  24.3E  [R0603]  79.76,32.77 90 top
D27:R42  24.3E  [R0603]  83.88,34.35 0 top
D27:R43  2K7  [R0603]  83.88,32.13 0 top
D27:R44  200E  [R0402]  92.46,32.77 0 top
D27:R45  1K5  [R0402]  92.46,35.31 180 top
D27:R46  10K  [R0402]  73.72,34.67 0 top
D27:R47  100K  [R0603]  74.04,32.45 270 top
D27:R48  20K  [R0402]  95.95,32.45 270 top
D27:R49  10E  [R0402]  92.46,35.94 0 bottom
D27:R50  470E  [R0402]  74.04,32.45 90 bottom
D27:R51  nc  [R0402]  92.46,36.58 180 top
D27:R61  nc  [R0402]  92.46,34.04 180 top
D27:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  88.65,35.31 90 top
D28:C1  100n  [C0402]  39.75,25.27 180 bottom
D28:C2  10n  [C0402]  39.75,26.54 180 bottom
D28:C3  100n  [C0402]  42.93,25.91 0 bottom
D28:C4  10n  [C0402]  42.93,27.18 0 bottom
D28:C7  10n  [C0402]  40.39,21.46 270 bottom
D28:C31  4.7n  [C0603]  30.54,27.5 180 top
D28:C32  150p  [C0402]  35.31,25.91 90 top
D28:C33  27p  [C0402]  39.75,26.23 90 top
D28:C34  nc  [C0402]  46.1,26.54 0 top
D28:C35  10n  [C0402]  44.83,21.46 180 bottom
D28:C36  100n  [C0603]  30.54,25.27 0 top
D28:C41  4.7n  [C0603]  30.54,20.83 180 top
D28:C42  150p  [C0402]  35.31,22.73 270 top
D28:C43  27p  [C0402]  39.75,21.46 270 top
D28:C44  nc  [C0402]  46.1,20.19 0 top
D28:C45  10n  [C0402]  46.1,26.54 180 bottom
D28:C46  100n  [C0603]  30.54,23.05 0 top
D28:R1  1K  [R0402]  38.16,21.78 180 bottom
D28:R31  24.3E  [R0603]  33.4,26.86 270 top
D28:R32  24.3E  [R0603]  37.53,25.27 0 top
D28:R33  2K7  [R0603]  37.53,27.5 0 top
D28:R34  200E  [R0402]  46.1,27.81 0 top
D28:R35  1K4  [R0402]  48.32,26.86 270 top
D28:R36  10K  [R0402]  27.37,24.64 180 top
D28:R37  100K  [R0603]  27.69,26.86 270 top
D28:R38  NC  [R0402]  49.91,26.23 270 top
D28:R39  10E  [R0402]  44.83,22.73 0 bottom
D28:R41  24.3E  [R0603]  33.4,21.46 90 top
D28:R42  24.3E  [R0603]  37.53,23.05 0 top
D28:R43  2K7  [R0603]  37.53,20.83 0 top
D28:R44  200E  [R0402]  46.1,21.46 0 top
D28:R45  1K5  [R0402]  46.1,24 180 top
D28:R46  10K  [R0402]  27.37,23.37 0 top
D28:R47  100K  [R0603]  27.69,21.15 270 top
D28:R48  20K  [R0402]  49.59,21.15 270 top
D28:R49  10E  [R0402]  46.1,24.64 0 bottom
D28:R50  470E  [R0402]  27.69,21.15 90 bottom
D28:R51  nc  [R0402]  46.1,25.27 180 top
D28:R61  nc  [R0402]  46.1,22.73 180 top
D28:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  42.29,24 90 top
D29:C1  100n  [C0402]  86.11,22.35 180 bottom
D29:C2  10n  [C0402]  86.11,23.62 180 bottom
D29:C3  100n  [C0402]  89.28,22.99 0 bottom
D29:C4  10n  [C0402]  89.28,24.26 0 bottom
D29:C7  10n  [C0402]  86.74,18.54 270 bottom
D29:C31  4.7n  [C0603]  76.9,24.57 180 top
D29:C32  150p  [C0402]  81.66,22.99 90 top
D29:C33  27p  [C0402]  86.11,23.3 90 top
D29:C34  nc  [C0402]  92.46,23.62 0 top
D29:C35  10n  [C0402]  91.19,18.54 180 bottom
D29:C36  100n  [C0603]  76.9,22.35 0 top
D29:C41  4.7n  [C0603]  76.9,17.91 180 top
D29:C42  150p  [C0402]  81.66,19.81 270 top
D29:C43  27p  [C0402]  86.11,18.54 270 top
D29:C44  nc  [C0402]  92.46,17.27 0 top
D29:C45  10n  [C0402]  92.46,23.62 180 bottom
D29:C46  100n  [C0603]  76.9,20.13 0 top
D29:R1  1K  [R0402]  84.52,18.86 180 bottom
D29:R31  24.3E  [R0603]  79.76,23.94 270 top
D29:R32  24.3E  [R0603]  83.88,22.35 0 top
D29:R33  2K7  [R0603]  83.88,24.57 0 top
D29:R34  200E  [R0402]  92.46,24.89 0 top
D29:R35  1K4  [R0402]  94.68,23.94 270 top
D29:R36  10K  [R0402]  73.72,21.72 180 top
D29:R37  100K  [R0603]  74.04,23.94 270 top
D29:R38  NC  [R0402]  96.27,23.3 270 top
D29:R39  10E  [R0402]  91.19,19.81 0 bottom
D29:R41  24.3E  [R0603]  79.76,18.54 90 top
D29:R42  24.3E  [R0603]  83.88,20.13 0 top
D29:R43  2K7  [R0603]  83.88,17.91 0 top
D29:R44  200E  [R0402]  92.46,18.54 0 top
D29:R45  1K5  [R0402]  92.46,21.08 180 top
D29:R46  10K  [R0402]  73.72,20.45 0 top
D29:R47  100K  [R0603]  74.04,18.22 270 top
D29:R48  20K  [R0402]  95.95,18.22 270 top
D29:R49  10E  [R0402]  92.46,21.72 0 bottom
D29:R50  470E  [R0402]  74.04,18.22 90 bottom
D29:R51  nc  [R0402]  92.46,22.35 180 top
D29:R61  nc  [R0402]  92.46,19.81 180 top
D29:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  88.65,21.08 90 top
D30:C1  100n  [C0402]  39.75,13.84 180 bottom
D30:C2  10n  [C0402]  39.75,15.11 180 bottom
D30:C3  100n  [C0402]  42.93,14.48 0 bottom
D30:C4  10n  [C0402]  42.93,15.75 0 bottom
D30:C7  10n  [C0402]  40.39,10.03 270 bottom
D30:C31  4.7n  [C0603]  30.54,16.07 180 top
D30:C32  150p  [C0402]  35.31,14.48 90 top
D30:C33  27p  [C0402]  39.75,14.8 90 top
D30:C34  nc  [C0402]  46.1,15.11 0 top
D30:C35  10n  [C0402]  44.83,10.03 180 bottom
D30:C36  100n  [C0603]  30.54,13.84 0 top
D30:C41  4.7n  [C0603]  30.54,9.4 180 top
D30:C42  150p  [C0402]  35.31,11.3 270 top
D30:C43  27p  [C0402]  39.75,10.03 270 top
D30:C44  nc  [C0402]  46.1,8.76 0 top
D30:C45  10n  [C0402]  46.1,15.11 180 bottom
D30:C46  100n  [C0603]  30.54,11.62 0 top
D30:R1  1K  [R0402]  38.16,10.35 180 bottom
D30:R31  24.3E  [R0603]  33.4,15.43 270 top
D30:R32  24.3E  [R0603]  37.53,13.84 0 top
D30:R33  2K7  [R0603]  37.53,16.07 0 top
D30:R34  200E  [R0402]  46.1,16.38 0 top
D30:R35  1K4  [R0402]  48.32,15.43 270 top
D30:R36  10K  [R0402]  27.37,13.21 180 top
D30:R37  100K  [R0603]  27.69,15.43 270 top
D30:R38  NC  [R0402]  49.91,14.8 270 top
D30:R39  10E  [R0402]  44.83,11.3 0 bottom
D30:R41  24.3E  [R0603]  33.4,10.03 90 top
D30:R42  24.3E  [R0603]  37.53,11.62 0 top
D30:R43  2K7  [R0603]  37.53,9.4 0 top
D30:R44  200E  [R0402]  46.1,10.03 0 top
D30:R45  1K5  [R0402]  46.1,12.57 180 top
D30:R46  10K  [R0402]  27.37,11.94 0 top
D30:R47  100K  [R0603]  27.69,9.72 270 top
D30:R48  20K  [R0402]  49.59,9.72 270 top
D30:R49  10E  [R0402]  46.1,13.21 0 bottom
D30:R50  470E  [R0402]  27.69,9.72 90 bottom
D30:R51  nc  [R0402]  46.1,13.84 180 top
D30:R61  nc  [R0402]  46.1,11.3 180 top
D30:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  42.29,12.57 90 top
D31:C1  100n  [C0402]  86.11,10.67 180 bottom
D31:C2  10n  [C0402]  86.11,11.94 180 bottom
D31:C3  100n  [C0402]  89.28,11.3 0 bottom
D31:C4  10n  [C0402]  89.28,12.57 0 bottom
D31:C7  10n  [C0402]  86.74,6.86 270 bottom
D31:C31  4.7n  [C0603]  76.9,12.89 180 top
D31:C32  150p  [C0402]  81.66,11.3 90 top
D31:C33  27p  [C0402]  86.11,11.62 90 top
D31:C34  nc  [C0402]  92.46,11.94 0 top
D31:C35  10n  [C0402]  91.19,6.86 180 bottom
D31:C36  100n  [C0603]  76.9,10.67 0 top
D31:C41  4.7n  [C0603]  76.9,6.22 180 top
D31:C42  150p  [C0402]  81.66,8.13 270 top
D31:C43  27p  [C0402]  86.11,6.86 270 top
D31:C44  nc  [C0402]  92.46,5.59 0 top
D31:C45  10n  [C0402]  92.46,11.94 180 bottom
D31:C46  100n  [C0603]  76.9,8.45 0 top
D31:R1  1K  [R0402]  84.52,7.18 180 bottom
D31:R31  24.3E  [R0603]  79.76,12.26 270 top
D31:R32  24.3E  [R0603]  83.88,10.67 0 top
D31:R33  2K7  [R0603]  83.88,12.89 0 top
D31:R34  200E  [R0402]  92.46,13.21 0 top
D31:R35  1K4  [R0402]  94.68,12.26 270 top
D31:R36  10K  [R0402]  73.72,10.03 180 top
D31:R37  100K  [R0603]  74.04,12.26 270 top
D31:R38  NC  [R0402]  96.27,11.62 270 top
D31:R39  10E  [R0402]  91.19,8.13 0 bottom
D31:R41  24.3E  [R0603]  79.76,6.86 90 top
D31:R42  24.3E  [R0603]  83.88,8.45 0 top
D31:R43  2K7  [R0603]  83.88,6.22 0 top
D31:R44  200E  [R0402]  92.46,6.86 0 top
D31:R45  1K5  [R0402]  92.46,9.4 180 top
D31:R46  10K  [R0402]  73.72,8.76 0 top
D31:R47  100K  [R0603]  74.04,6.54 270 top
D31:R48  20K  [R0402]  95.95,6.54 270 top
D31:R49  10E  [R0402]  92.46,10.03 0 bottom
D31:R50  470E  [R0402]  74.04,6.54 90 bottom
D31:R51  nc  [R0402]  92.46,10.67 180 top
D31:R61  nc  [R0402]  92.46,8.13 180 top
D31:U1  AD8132ARZMSOP  [SOP65P490X110-8N]  88.65,9.4 90 top
F1  0.1A F  [FUSE1206]  124.08,10.79 270 top
F2  1A F  [FUSE1206]  134.87,107.95 0 top
F3  1A F  [FUSE1206]  134.87,113.03 180 top
GPIO2  UA_TPPAD1-13  [UA_P1-13]  136.78,193.04 0 top
HVIN  UA_TPPAD1-13  [UA_P1-13]  121.54,12.06 0 top
LD1  UA_TPPAD1-13  [UA_P1-13]  14.22,189.23 0 top
LDAC2  UA_TPPAD1-13  [UA_P1-13]  59.94,187.32 0 top
LDAC3  UA_TPPAD1-13  [UA_P1-13]  14.86,137.79 0 top
LDAC4  UA_TPPAD1-13  [UA_P1-13]  60.58,139.7 0 top
LDAC5  UA_TPPAD1-13  [UA_P1-13]  14.86,76.83 0 top
LDAC6  UA_TPPAD1-13  [UA_P1-13]  57.4,73.66 0 top
LDAC7  UA_TPPAD1-13  [UA_P1-13]  15.24,26.04 0 top
LDAC8  UA_TPPAD1-13  [UA_P1-13]  58.67,21.59 0 top
LED1  HSMG-C170  [CHIP-LED0805]  108.2,111.76 270 top
M1  [UA]  106.3,162.24 0 top
R1  10K  [R0402]  108.97,116.59 270 top
R2  27K  [R0402]  132.33,95.89 90 top
R3  10K  [R0402]  132.46,91.95 90 top
R4  10E  [R0402]  12.95,192.41 0 top
R5  4K7  [R0402]  14.86,186.69 0 top
R6  0  [R0805]  132.84,128.14 90 top
R7  4K7  [R0402]  110.11,107.31 90 top
R8  100E  [M1206]  124.1,15.06 0 top
R9  NC  [R0805H]  109.5,14.02 90 top
R10  10E  [R0402]  59.31,191.13 90 top
R11  4K7  [R0402]  56.77,186.69 0 top
R12  4K7  [R0402]  136.14,76.2 90 top
R13  4K7  [R0402]  118.36,83.82 0 top
R14  3K3  [R0402]  135.51,199.39 180 top
R15  27K  [R0402]  110.11,7.62 0 top
R16  10K  [R0402]  122.17,7.62 90 top
R17  1K  [R0805H]  113.28,14.61 180 top
R18  1K  [R0402]  121.46,17.45 180 top
R19  2K4  [R0402]  118.36,5.84 0 top
R20  3K3  [R0402]  136.14,203.2 90 top
R21  10E  [R0402]  19.3,143.64 180 top
R22  4K7  [R0402]  12.32,140.97 270 top
R23  NC  [R0402]  118.36,104.78 90 top
R24  10E  [R0402]  61.21,143.51 0 top
R25  4K7  [R0402]  58.04,139.7 0 top
R26  0  [R0805]  122.05,104.78 0 top
R27  NC  [R0402]  132.97,125.09 0 top
R28  10E  [R0402]  15.49,80.64 90 top
R29  4K7  [R0402]  12.32,76.2 0 top
R30  27K  [R0402]  122.17,109.86 90 top
R31  10K  [R0402]  121.54,107.31 0 top
R32  4K7  [R0402]  112.65,104.14 270 top
R33  NC  [R0402]  117.09,198.12 0 top
R34  3K3  [R0402]  135.51,80.64 90 top
R35  10E  [R0402]  56.77,78.11 90 top
R36  4K7  [R0402]  55.5,71.75 0 top
R37  3K3  [R0402]  135.51,84.45 270 top
R38  10K  [R0402]  121.54,70.48 270 top
R39  100E  [M1206]  130.96,15.44 0 top
R40  10E  [R0402]  14.86,31.75 90 top
R41  4K7  [R0402]  13.33,26.67 270 top
R43  10E  [R0402]  58.04,26.04 90 top
R44  4K7  [R0402]  56.13,20.95 0 top
R46  4K7  [R0402]  130.43,195.58 180 top
R47  3K3  [R0402]  116.84,78.87 180 top
R48  3K3  [R0402]  110.74,85.09 0 top
R49  3K3  [R0402]  116.46,200.66 270 top
R50  NC  [R0402]  128.14,102.87 0 top
R51  3K3  [R0402]  117.09,205.1 90 top
R52  12K  [R0402]  121.54,127.64 270 top
R53  18K  [R0402]  121.54,123.83 90 top
R54  10K  [R0402]  130.68,125.48 270 top
R57  10K  [R0402]  123.44,70.48 90 top
R58  10K  [R0402]  133.6,193.68 180 top
R59  10K  [R0402]  123.57,192.41 0 top
T2  UA_TPPAD1-13  [UA_P1-13]  117.73,17.14 0 top
T4  UA_TPPAD1-13  [UA_P1-13]  131.06,107.95 0 top
T5D  UA_TPPAD1-13  [UA_P1-13]  130.43,96.52 0 top
T5V  UA_TPPAD1-13  [UA_P1-13]  120.27,110.49 0 top
T6  UA_TPPAD1-13  [UA_P1-13]  112.01,106.81 0 top
T7  UA_TPPAD1-13  [UA_P1-13]  114.55,104.78 0 top
T13  UA_TPPAD1-13  [UA_P1-13]  112.65,77.47 0 top
T14  UA_TPPAD1-13  [UA_P1-13]  109.47,10.16 0 top
T15  UA_TPPAD1-13  [UA_P1-13]  124.08,6.99 0 top
T16  UA_TPPAD1-13  [UA_P1-13]  116.46,8.89 0 top
TG1  UA_TPPAD1-13  [UA_P1-13]  112.01,113.67 0 top
TG2  UA_TPPAD1-13  [UA_P1-13]  14.22,111.76 0 top
TG3  UA_TPPAD1-13  [UA_P1-13]  54.23,102.23 0 top
TG4  UA_TPPAD1-13  [UA_P1-13]  58.67,209.55 0 top
TG5  UA_TPPAD1-13  [UA_P1-13]  14.99,201.04 0 top
TM5  UA_TPPAD1-13  [UA_P1-13]  132.97,118.75 0 top
TVN3  UA_TPPAD1-13  [UA_P1-13]  112.65,123.19 0 top
U1  MCP4728-E/UN  [SOP50P490X110-10N]  18.67,189.87 0 top
U2  MCP4728-E/UN  [SOP50P490X110-10N]  63.75,188.59 0 top
U3  ADL5317  [LFCSP_LQ-16_MANSOL]  113.28,10.16 180 top
U4  MCP4725A0T-E/CH  [SOT95P270X145-6N]  116.46,81.28 0 top
U5  TCA9406DCUR  [SOP50P310X90-8N]  119.63,202.56 90 top
U6  MCP4728-E/UN  [SOP50P490X110-10N]  18.67,138.43 0 top
U7  MCP4728-E/UN  [SOP50P490X110-10N]  65.02,140.97 0 top
U9  MCP4728-E/UN  [SOP50P490X110-10N]  19.3,77.47 0 top
U10  MCP4728-E/UN  [SOP50P490X110-10N]  61.85,74.93 0 top
U11  MCP4728-E/UN  [SOP50P490X110-10N]  18.03,28.57 0 top
U12  MCP4728-E/UN  [SOP50P490X110-10N]  63.12,22.86 0 top
U13  TCA9406DCUR  [SOP50P310X90-8N]  122.56,82.17 90 top
U14  LT3015EMSEM  [SOP65P490X110H-13N]  125.98,123.19 180 top
U17  MCP6001T-I/LT  [SOT65P240X110-5N]  127.89,71.12 0 top
U19  MCP6001T-I/LT  [SOT65P240X110-5N]  119,192.41 180 top
U20  AT30TSE752-XM8-B  [SOP65P490X110-8N']  109.47,101.6 90 top
U21  LP38692MP-ADJ  [SOT150P696X180-5N]  115.06,109.73 180 top
U22  LP38692MP-ADJ  [SOT150P696X180-5N]  125.35,95.63 180 top
U$1  [UA_LOGO_SOLD]  118.62,161.54 0 top
V5E1  UA_TPPAD1-13  [UA_P1-13]  134.87,90.17 0 top
V5E2  UA_TPPAD1-13  [UA_P1-13]  136.14,208.28 0 top
VB  UA_TPPAD1-13  [UA_P1-13]  106.25,13.36 0 top
X1  MAB64  [MAB64]  2.79,168.91 180 top
X2  MAB64  [MAB64]  2.79,50.8 180 top
X3  DIN41612_ABC_96_R  [DIN41612_96RC]  141.6,168.91 0 top
X4  DIN41612_ABC_96_R  [DIN41612_96RC]  141.6,50.8 0 top
X5  22-23-2041  [22-23-2041]  131.06,82.55 90 top
X6  22-23-2021  [22-23-2021]  130.43,10.79 90 top
X7  22-23-2041  [22-23-2041]  129.79,201.93 90 top
X8  22-23-2031  [22-23-2031]  141.22,110.49 90 top

## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
BIASSET  (via drill 0.6)
  Top 0.254: U3.2 115.31,9.91 116.2,9.65 116.2,9.14 T16.TP 116.42,5.97 | R19.1 116.42,5.97 | 116.42,5.97 C27.1 | R18.2 v119.63,15.89 v119.63,15.88
  Route3 0.254: v119.63,15.88 116.46,13.97 T16.TP
BIASTRSET  (via drill 0.6)
  Top 0.254: U4.1 112.65,82.55 110.74,82.55 110.74,79.38 T13.TP | R18.1 123.5,17.52 v124.77,17.58
  Route2 0.254: v120.27,76.2 113.28,76.2 T13.TP
  Route3 0.254: v124.77,17.58 120.27,20.95 v120.27,76.2
D0:AMP+
  Top 0.254: 42.59,205.28 39.43,205.3 39.13,205.6 D0:C43.2 38.39,205.6 D0:R43.2 | 42.59,205.28 42.61,205.93 42.61,206.74 D0:U1.4 | 42.59,205.28 42.61,205.3 D0:C44.1 D0:R44.1 D0:R61.2
D0:AMP-
  Top 0.254: D0:R33.2 38.36,211.66 D0:C33.2 39.45,211.66 40.07,212.28 42.62,212.28 | 42.62,212.28 D0:U1.5 | 42.62,212.28 44.5,212.28 D0:R34.1 D0:C34.1 D0:R51.2
D0:FB+
  Top 0.254: D0:R32.1 D0:R33.1 34.67,212.28 D0:C32.2 D0:R31.2
D0:FB-
  Top 0.254: D0:R43.1 36.04,206.88 | 36.04,206.88 D0:R42.1 | D0:R41.2 D0:C42.2 34.67,206.88 36.04,206.88
D0:N$1  (via drill 0.4)
  Top 0.254: D0:R51.1 D0:R49.1 | D0:R49.1 D0:R45.1 | v47.37,209.42 D0:R49.1
  BOTTOM 0.254: D0:C45.2 D0:R49.1 v47.37,209.42
D0:N$4
  Top 0.254: D0:U1.1 38.97,206.76 D0:C43.1 38.78,206.58 37.85,207.52 D0:R42.2
D0:N$5
  Top 0.254: D0:U1.8 40.51,210.82 40.39,210.69 40.07,210.69 39.75,210.38 39.13,210.38 D0:C33.1 38.05,210.36 D0:R32.2
D0:N$7  (via drill 0.4)
  Top 0.254: D0:R61.1 v47.69,207.52 48.32,208.15 48.32,210.06 D0:R35.2
  BOTTOM 0.254: D0:C35.2 D0:R39.1 45.16,207.84 46.42,207.84 46.74,207.52 v47.69,207.52
D0:N$10
  Top 0.406: D0:R41.1 30.97,205.4 D0:C41.1
D0:R31
  Top 0.406: D0:R31.1 30.97,212.5 D0:C31.1
D0:VB+
  Top 0.406: D0:R37.2 27.05,210.69 27.37,210.38 27.37,210.06 | 27.37,210.06 27.37,209.44 D0:R36.1 | D0:C36.1 27.37,210.06
D0:VB-  (via drill 0.4)
  Top 0.406: D0:C46.1 28.74,208.15 D0:R46.2 27.37,208.14 27.37,207.2 27.05,206.88 D0:R47.1 26.84,206.56 v25.46,206.88
  BOTTOM 0.406: D0:R50.2 25.48,206.9 v25.46,206.88
D0:VCOM  (via drill 0.4)
  Top 0.254: D0:U1.2 41.33,207.5 41.34,207.52 41.34,207.84 41.02,208.15 v39.43,208.47
  BOTTOM 0.254: v39.43,208.47 D0:C7.1 38.19,206.58 D0:R1.2
D1:AMP+
  Top 0.254: 89.58,202.99 86.42,203.01 86.12,203.31 D1:C43.2 85.38,203.31 D1:R43.2 | 89.58,202.99 89.6,203.64 89.6,204.46 D1:U1.4 | 89.58,202.99 89.6,203.01 D1:C44.1 D1:R44.1 D1:R61.2
D1:AMP-
  Top 0.254: D1:R33.2 85.35,209.38 D1:C33.2 86.44,209.38 87.06,209.99 89.61,209.99 | 89.61,209.99 D1:U1.5 | 89.61,209.99 91.49,209.99 D1:R34.1 D1:C34.1 D1:R51.2
D1:FB+
  Top 0.254: D1:R32.1 D1:R33.1 81.66,209.99 D1:C32.2 D1:R31.2
D1:FB-
  Top 0.254: D1:R43.1 83.03,204.6 | 83.03,204.6 D1:R42.1 | D1:R41.2 D1:C42.2 81.66,204.6 83.03,204.6
D1:N$1  (via drill 0.4)
  Top 0.254: D1:R51.1 D1:R49.1 | D1:R49.1 D1:R45.1 | v94.36,207.14 D1:R49.1
  BOTTOM 0.254: D1:C45.2 D1:R49.1 v94.36,207.14
D1:N$4
  Top 0.254: D1:U1.1 85.96,204.47 D1:C43.1 85.77,204.29 84.84,205.23 D1:R42.2
D1:N$5
  Top 0.254: D1:U1.8 87.5,208.53 87.38,208.41 87.06,208.41 86.74,208.09 86.12,208.09 D1:C33.1 85.04,208.07 D1:R32.2
D1:N$7  (via drill 0.4)
  Top 0.254: D1:R61.1 v94.68,205.23 95.31,205.87 95.31,207.77 D1:R35.2
  BOTTOM 0.254: D1:C35.2 D1:R39.1 92.15,205.55 93.41,205.55 93.73,205.23 v94.68,205.23
D1:N$10
  Top 0.406: D1:R41.1 77.96,203.11 D1:C41.1
D1:R31
  Top 0.406: D1:R31.1 77.96,210.21 D1:C31.1
D1:VB+
  Top 0.406: D1:R37.2 74.04,208.41 74.36,208.09 74.36,207.77 | 74.36,207.77 74.36,207.15 D1:R36.1 | D1:C36.1 74.36,207.77
D1:VB-  (via drill 0.4)
  Top 0.406: D1:C46.1 75.73,205.87 D1:R46.2 74.36,205.85 74.36,204.91 74.04,204.6 D1:R47.1 73.83,204.28 v72.45,204.6
  BOTTOM 0.406: D1:R50.2 72.47,204.61 v72.45,204.6
D1:VCOM  (via drill 0.4)
  Top 0.254: D1:U1.2 88.32,205.22 88.33,205.23 88.33,205.55 88.01,205.87 v86.42,206.19
  BOTTOM 0.254: v86.42,206.19 D1:C7.1 85.18,204.29 D1:R1.2
D2:AMP+
  Top 0.254: 42.59,193.85 39.43,193.87 39.13,194.17 D2:C43.2 38.39,194.17 D2:R43.2 | 42.59,193.85 42.61,194.5 42.61,195.31 D2:U1.4 | 42.59,193.85 42.61,193.87 D2:C44.1 D2:R44.1 D2:R61.2
D2:AMP-
  Top 0.254: D2:R33.2 38.36,200.23 D2:C33.2 39.45,200.23 40.07,200.85 42.62,200.85 | 42.62,200.85 D2:U1.5 | 42.62,200.85 44.5,200.85 D2:R34.1 D2:C34.1 D2:R51.2
D2:FB+
  Top 0.254: D2:R32.1 D2:R33.1 34.67,200.85 D2:C32.2 D2:R31.2
D2:FB-
  Top 0.254: D2:R43.1 36.04,195.45 | 36.04,195.45 D2:R42.1 | D2:R41.2 D2:C42.2 34.67,195.45 36.04,195.45
D2:N$1  (via drill 0.4)
  Top 0.254: D2:R51.1 D2:R49.1 | D2:R49.1 D2:R45.1 | v47.37,197.99 D2:R49.1
  BOTTOM 0.254: D2:C45.2 D2:R49.1 v47.37,197.99
D2:N$4
  Top 0.254: D2:U1.1 38.97,195.33 D2:C43.1 38.78,195.15 37.85,196.09 D2:R42.2
D2:N$5
  Top 0.254: D2:U1.8 40.51,199.39 40.39,199.26 40.07,199.26 39.75,198.95 39.13,198.95 D2:C33.1 38.05,198.93 D2:R32.2
D2:N$7  (via drill 0.4)
  Top 0.254: D2:R61.1 v47.69,196.09 48.32,196.72 48.32,198.63 D2:R35.2
  BOTTOM 0.254: D2:C35.2 D2:R39.1 45.16,196.41 46.42,196.41 46.74,196.09 v47.69,196.09
D2:N$10
  Top 0.406: D2:R41.1 30.97,193.97 D2:C41.1
D2:R31
  Top 0.406: D2:R31.1 30.97,201.06 D2:C31.1
D2:VB+
  Top 0.406: D2:R37.2 27.05,199.26 27.37,198.95 27.37,198.63 | 27.37,198.63 27.37,198.01 D2:R36.1 | D2:C36.1 27.37,198.63
D2:VB-  (via drill 0.4)
  Top 0.406: D2:C46.1 28.74,196.72 D2:R46.2 27.37,196.71 27.37,195.77 27.05,195.45 D2:R47.1 26.84,195.14 v25.46,195.45
  BOTTOM 0.406: D2:R50.2 25.48,195.47 v25.46,195.45
D2:VCOM  (via drill 0.4)
  Top 0.254: D2:U1.2 41.33,196.07 41.34,196.09 41.34,196.41 41.02,196.72 v39.43,197.04
  BOTTOM 0.254: v39.43,197.04 D2:C7.1 38.19,195.15 D2:R1.2
D3:AMP+
  Top 0.254: 89.58,191.06 86.42,191.07 86.12,191.37 D3:C43.2 85.38,191.37 D3:R43.2 | 89.58,191.06 89.6,191.71 89.6,192.52 D3:U1.4 | 89.58,191.06 89.6,191.07 D3:C44.1 D3:R44.1 D3:R61.2
D3:AMP-
  Top 0.254: D3:R33.2 85.35,197.44 D3:C33.2 86.44,197.44 87.06,198.06 89.61,198.06 | 89.61,198.06 D3:U1.5 | 89.61,198.06 91.49,198.06 D3:R34.1 D3:C34.1 D3:R51.2
D3:FB+
  Top 0.254: D3:R32.1 D3:R33.1 81.66,198.06 D3:C32.2 D3:R31.2
D3:FB-
  Top 0.254: D3:R43.1 83.03,192.66 | 83.03,192.66 D3:R42.1 | D3:R41.2 D3:C42.2 81.66,192.66 83.03,192.66
D3:N$1  (via drill 0.4)
  Top 0.254: D3:R51.1 D3:R49.1 | D3:R49.1 D3:R45.1 | v94.36,195.2 D3:R49.1
  BOTTOM 0.254: D3:C45.2 D3:R49.1 v94.36,195.2
D3:N$4
  Top 0.254: D3:U1.1 85.96,192.53 D3:C43.1 85.77,192.36 84.84,193.29 D3:R42.2
D3:N$5
  Top 0.254: D3:U1.8 87.5,196.6 87.38,196.47 87.06,196.47 86.74,196.15 86.12,196.15 D3:C33.1 85.04,196.14 D3:R32.2
D3:N$7  (via drill 0.4)
  Top 0.254: D3:R61.1 v94.68,193.29 95.31,193.93 95.31,195.83 D3:R35.2
  BOTTOM 0.254: D3:C35.2 D3:R39.1 92.15,193.61 93.41,193.61 93.73,193.29 v94.68,193.29
D3:N$10
  Top 0.406: D3:R41.1 77.96,191.17 D3:C41.1
D3:R31
  Top 0.406: D3:R31.1 77.96,198.27 D3:C31.1
D3:VB+
  Top 0.406: D3:R37.2 74.04,196.47 74.36,196.15 74.36,195.83 | 74.36,195.83 74.36,195.21 D3:R36.1 | D3:C36.1 74.36,195.83
D3:VB-  (via drill 0.4)
  Top 0.406: D3:C46.1 75.73,193.93 D3:R46.2 74.36,193.91 74.36,192.98 74.04,192.66 D3:R47.1 73.83,192.34 v72.45,192.66
  BOTTOM 0.406: D3:R50.2 72.47,192.67 v72.45,192.66
D3:VCOM  (via drill 0.4)
  Top 0.254: D3:U1.2 88.32,193.28 88.33,193.29 88.33,193.61 88.01,193.93 v86.42,194.25
  BOTTOM 0.254: v86.42,194.25 D3:C7.1 85.18,192.36 D3:R1.2
D4:AMP+
  Top 0.254: 42.59,178.61 39.43,178.62 39.13,178.93 D4:C43.2 38.39,178.93 D4:R43.2 | 42.59,178.61 42.61,179.26 42.61,180.07 D4:U1.4 | 42.59,178.61 42.61,178.62 D4:C44.1 D4:R44.1 D4:R61.2
D4:AMP-
  Top 0.254: D4:R33.2 38.36,184.99 D4:C33.2 39.45,184.99 40.07,185.61 42.62,185.61 | 42.62,185.61 D4:U1.5 | 42.62,185.61 44.5,185.61 D4:R34.1 D4:C34.1 D4:R51.2
D4:FB+
  Top 0.254: D4:R32.1 D4:R33.1 34.67,185.61 D4:C32.2 D4:R31.2
D4:FB-
  Top 0.254: D4:R43.1 36.04,180.21 | 36.04,180.21 D4:R42.1 | D4:R41.2 D4:C42.2 34.67,180.21 36.04,180.21
D4:N$1  (via drill 0.4)
  Top 0.254: D4:R51.1 D4:R49.1 | D4:R49.1 D4:R45.1 | v47.37,182.75 D4:R49.1
  BOTTOM 0.254: D4:C45.2 D4:R49.1 v47.37,182.75
D4:N$4
  Top 0.254: D4:U1.1 38.97,180.09 D4:C43.1 38.78,179.91 37.85,180.85 D4:R42.2
D4:N$5
  Top 0.254: D4:U1.8 40.51,184.15 40.39,184.02 40.07,184.02 39.75,183.71 39.13,183.71 D4:C33.1 38.05,183.69 D4:R32.2
D4:N$7  (via drill 0.4)
  Top 0.254: D4:R61.1 v47.69,180.85 48.32,181.48 48.32,183.39 D4:R35.2
  BOTTOM 0.254: D4:C35.2 D4:R39.1 45.16,181.17 46.42,181.17 46.74,180.85 v47.69,180.85
D4:N$10
  Top 0.406: D4:R41.1 30.97,178.73 D4:C41.1
D4:R31
  Top 0.406: D4:R31.1 30.97,185.83 D4:C31.1
D4:VB+
  Top 0.406: D4:R37.2 27.05,184.02 27.37,183.71 27.37,183.39 | 27.37,183.39 27.37,182.77 D4:R36.1 | D4:C36.1 27.37,183.39
D4:VB-  (via drill 0.4)
  Top 0.406: D4:C46.1 28.74,181.48 D4:R46.2 27.37,181.47 27.37,180.53 27.05,180.21 D4:R47.1 26.84,179.9 v25.46,180.21
  BOTTOM 0.406: D4:R50.2 25.48,180.23 v25.46,180.21
D4:VCOM  (via drill 0.4)
  Top 0.254: D4:U1.2 41.33,180.84 41.34,180.85 41.34,181.17 41.02,181.48 v39.43,181.8
  BOTTOM 0.254: v39.43,181.8 D4:C7.1 38.19,179.91 D4:R1.2
D5:AMP+
  Top 0.254: 89.58,176.07 86.42,176.09 86.12,176.39 D5:C43.2 85.38,176.39 D5:R43.2 | 89.58,176.07 89.6,176.72 89.6,177.53 D5:U1.4 | 89.58,176.07 89.6,176.09 D5:C44.1 D5:R44.1 D5:R61.2
D5:AMP-
  Top 0.254: D5:R33.2 85.35,182.45 D5:C33.2 86.44,182.45 87.06,183.07 89.61,183.07 | 89.61,183.07 D5:U1.5 | 89.61,183.07 91.49,183.07 D5:R34.1 D5:C34.1 D5:R51.2
D5:FB+
  Top 0.254: D5:R32.1 D5:R33.1 81.66,183.07 D5:C32.2 D5:R31.2
D5:FB-
  Top 0.254: D5:R43.1 83.03,177.67 | 83.03,177.67 D5:R42.1 | D5:R41.2 D5:C42.2 81.66,177.67 83.03,177.67
D5:N$1  (via drill 0.4)
  Top 0.254: D5:R51.1 D5:R49.1 | D5:R49.1 D5:R45.1 | v94.36,180.21 D5:R49.1
  BOTTOM 0.254: D5:C45.2 D5:R49.1 v94.36,180.21
D5:N$4
  Top 0.254: D5:U1.1 85.96,177.55 D5:C43.1 85.77,177.37 84.84,178.31 D5:R42.2
D5:N$5
  Top 0.254: D5:U1.8 87.5,181.61 87.38,181.48 87.06,181.48 86.74,181.17 86.12,181.17 D5:C33.1 85.04,181.15 D5:R32.2
D5:N$7  (via drill 0.4)
  Top 0.254: D5:R61.1 v94.68,178.31 95.31,178.94 95.31,180.85 D5:R35.2
  BOTTOM 0.254: D5:C35.2 D5:R39.1 92.15,178.62 93.41,178.62 93.73,178.31 v94.68,178.31
D5:N$10
  Top 0.406: D5:R41.1 77.96,176.19 D5:C41.1
D5:R31
  Top 0.406: D5:R31.1 77.96,183.29 D5:C31.1
D5:VB+
  Top 0.406: D5:R37.2 74.04,181.48 74.36,181.17 74.36,180.85 | 74.36,180.85 74.36,180.23 D5:R36.1 | D5:C36.1 74.36,180.85
D5:VB-  (via drill 0.4)
  Top 0.406: D5:C46.1 75.73,178.94 D5:R46.2 74.36,178.93 74.36,177.99 74.04,177.67 D5:R47.1 73.83,177.36 v72.45,177.67
  BOTTOM 0.406: D5:R50.2 72.47,177.69 v72.45,177.67
D5:VCOM  (via drill 0.4)
  Top 0.254: D5:U1.2 88.32,178.29 88.33,178.31 88.33,178.62 88.01,178.94 v86.42,179.26
  BOTTOM 0.254: v86.42,179.26 D5:C7.1 85.18,177.37 D5:R1.2
D6:AMP+
  Top 0.254: 42.59,165.91 39.43,165.93 39.13,166.23 D6:C43.2 38.39,166.23 D6:R43.2 | 42.59,165.91 42.61,166.56 42.61,167.37 D6:U1.4 | 42.59,165.91 42.61,165.93 D6:C44.1 D6:R44.1 D6:R61.2
D6:AMP-
  Top 0.254: D6:R33.2 38.36,172.29 D6:C33.2 39.45,172.29 40.07,172.91 42.62,172.91 | 42.62,172.91 D6:U1.5 | 42.62,172.91 44.5,172.91 D6:R34.1 D6:C34.1 D6:R51.2
D6:FB+
  Top 0.254: D6:R32.1 D6:R33.1 34.67,172.91 D6:C32.2 D6:R31.2
D6:FB-
  Top 0.254: D6:R43.1 36.04,167.51 | 36.04,167.51 D6:R42.1 | D6:R41.2 D6:C42.2 34.67,167.51 36.04,167.51
D6:N$1  (via drill 0.4)
  Top 0.254: D6:R51.1 D6:R49.1 | D6:R49.1 D6:R45.1 | v47.37,170.05 D6:R49.1
  BOTTOM 0.254: D6:C45.2 D6:R49.1 v47.37,170.05
D6:N$4
  Top 0.254: D6:U1.1 38.97,167.39 D6:C43.1 38.78,167.21 37.85,168.15 D6:R42.2
D6:N$5
  Top 0.254: D6:U1.8 40.51,171.45 40.39,171.32 40.07,171.32 39.75,171.01 39.13,171.01 D6:C33.1 38.05,170.99 D6:R32.2
D6:N$7  (via drill 0.4)
  Top 0.254: D6:R61.1 v47.69,168.15 48.32,168.78 48.32,170.69 D6:R35.2
  BOTTOM 0.254: D6:C35.2 D6:R39.1 45.16,168.47 46.42,168.47 46.74,168.15 v47.69,168.15
D6:N$10
  Top 0.406: D6:R41.1 30.97,166.03 D6:C41.1
D6:R31
  Top 0.406: D6:R31.1 30.97,173.12 D6:C31.1
D6:VB+
  Top 0.406: D6:R37.2 27.05,171.32 27.37,171.01 27.37,170.69 | 27.37,170.69 27.37,170.07 D6:R36.1 | D6:C36.1 27.37,170.69
D6:VB-  (via drill 0.4)
  Top 0.406: D6:C46.1 28.74,168.78 D6:R46.2 27.37,168.77 27.37,167.83 27.05,167.51 D6:R47.1 26.84,167.2 v25.46,167.51
  BOTTOM 0.406: D6:R50.2 25.48,167.53 v25.46,167.51
D6:VCOM  (via drill 0.4)
  Top 0.254: D6:U1.2 41.33,168.13 41.34,168.15 41.34,168.47 41.02,168.78 v39.43,169.1
  BOTTOM 0.254: v39.43,169.1 D6:C7.1 38.19,167.21 D6:R1.2
D7:AMP+
  Top 0.254: 89.58,164.64 86.42,164.66 86.12,164.96 D7:C43.2 85.38,164.96 D7:R43.2 | 89.58,164.64 89.6,165.29 89.6,166.1 D7:U1.4 | 89.58,164.64 89.6,164.66 D7:C44.1 D7:R44.1 D7:R61.2
D7:AMP-
  Top 0.254: D7:R33.2 85.35,171.02 D7:C33.2 86.44,171.02 87.06,171.64 89.61,171.64 | 89.61,171.64 D7:U1.5 | 89.61,171.64 91.49,171.64 D7:R34.1 D7:C34.1 D7:R51.2
D7:FB+
  Top 0.254: D7:R32.1 D7:R33.1 81.66,171.64 D7:C32.2 D7:R31.2
D7:FB-
  Top 0.254: D7:R43.1 83.03,166.24 | 83.03,166.24 D7:R42.1 | D7:R41.2 D7:C42.2 81.66,166.24 83.03,166.24
D7:N$1  (via drill 0.4)
  Top 0.254: D7:R51.1 D7:R49.1 | D7:R49.1 D7:R45.1 | v94.36,168.78 D7:R49.1
  BOTTOM 0.254: D7:C45.2 D7:R49.1 v94.36,168.78
D7:N$4
  Top 0.254: D7:U1.1 85.96,166.12 D7:C43.1 85.77,165.94 84.84,166.88 D7:R42.2
D7:N$5
  Top 0.254: D7:U1.8 87.5,170.18 87.38,170.05 87.06,170.05 86.74,169.74 86.12,169.74 D7:C33.1 85.04,169.72 D7:R32.2
D7:N$7  (via drill 0.4)
  Top 0.254: D7:R61.1 v94.68,166.88 95.31,167.51 95.31,169.42 D7:R35.2
  BOTTOM 0.254: D7:C35.2 D7:R39.1 92.15,167.2 93.41,167.2 93.73,166.88 v94.68,166.88
D7:N$10
  Top 0.406: D7:R41.1 77.96,164.76 D7:C41.1
D7:R31
  Top 0.406: D7:R31.1 77.96,171.86 D7:C31.1
D7:VB+
  Top 0.406: D7:R37.2 74.04,170.05 74.36,169.74 74.36,169.42 | 74.36,169.42 74.36,168.8 D7:R36.1 | D7:C36.1 74.36,169.42
D7:VB-  (via drill 0.4)
  Top 0.406: D7:C46.1 75.73,167.51 D7:R46.2 74.36,167.5 74.36,166.56 74.04,166.24 D7:R47.1 73.83,165.93 v72.45,166.24
  BOTTOM 0.406: D7:R50.2 72.47,166.26 v72.45,166.24
D7:VCOM  (via drill 0.4)
  Top 0.254: D7:U1.2 88.32,166.87 88.33,166.88 88.33,167.2 88.01,167.51 v86.42,167.83
  BOTTOM 0.254: v86.42,167.83 D7:C7.1 85.18,165.94 D7:R1.2
D8:AMP+
  Top 0.254: 42.59,153.21 39.43,153.23 39.13,153.53 D8:C43.2 38.39,153.53 D8:R43.2 | 42.59,153.21 42.61,153.86 42.61,154.67 D8:U1.4 | 42.59,153.21 42.61,153.23 D8:C44.1 D8:R44.1 D8:R61.2
D8:AMP-
  Top 0.254: D8:R33.2 38.36,159.59 D8:C33.2 39.45,159.59 40.07,160.21 42.62,160.21 | 42.62,160.21 D8:U1.5 | 42.62,160.21 44.5,160.21 D8:R34.1 D8:C34.1 D8:R51.2
D8:FB+
  Top 0.254: D8:R32.1 D8:R33.1 34.67,160.21 D8:C32.2 D8:R31.2
D8:FB-
  Top 0.254: D8:R43.1 36.04,154.81 | 36.04,154.81 D8:R42.1 | D8:R41.2 D8:C42.2 34.67,154.81 36.04,154.81
D8:N$1  (via drill 0.4)
  Top 0.254: D8:R51.1 D8:R49.1 | D8:R49.1 D8:R45.1 | v47.37,157.35 D8:R49.1
  BOTTOM 0.254: D8:C45.2 D8:R49.1 v47.37,157.35
D8:N$4
  Top 0.254: D8:U1.1 38.97,154.69 D8:C43.1 38.78,154.51 37.85,155.45 D8:R42.2
D8:N$5
  Top 0.254: D8:U1.8 40.51,158.75 40.39,158.62 40.07,158.62 39.75,158.31 39.13,158.31 D8:C33.1 38.05,158.29 D8:R32.2
D8:N$7  (via drill 0.4)
  Top 0.254: D8:R61.1 v47.69,155.45 48.32,156.08 48.32,157.99 D8:R35.2
  BOTTOM 0.254: D8:C35.2 D8:R39.1 45.16,155.77 46.42,155.77 46.74,155.45 v47.69,155.45
D8:N$10
  Top 0.406: D8:R41.1 30.97,153.33 D8:C41.1
D8:R31
  Top 0.406: D8:R31.1 30.97,160.43 D8:C31.1
D8:VB+
  Top 0.406: D8:R37.2 27.05,158.62 27.37,158.31 27.37,157.99 | 27.37,157.99 27.37,157.37 D8:R36.1 | D8:C36.1 27.37,157.99
D8:VB-  (via drill 0.4)
  Top 0.406: D8:C46.1 28.74,156.08 D8:R46.2 27.37,156.07 27.37,155.13 27.05,154.81 D8:R47.1 26.84,154.5 v25.46,154.81
  BOTTOM 0.406: D8:R50.2 25.48,154.83 v25.46,154.81
D8:VCOM  (via drill 0.4)
  Top 0.254: D8:U1.2 41.33,155.44 41.34,155.45 41.34,155.77 41.02,156.08 v39.43,156.4
  BOTTOM 0.254: v39.43,156.4 D8:C7.1 38.19,154.51 D8:R1.2
D9:AMP+
  Top 0.254: 89.58,151.94 86.42,151.96 86.12,152.26 D9:C43.2 85.38,152.26 D9:R43.2 | 89.58,151.94 89.6,152.59 89.6,153.4 D9:U1.4 | 89.58,151.94 89.6,151.96 D9:C44.1 D9:R44.1 D9:R61.2
D9:AMP-
  Top 0.254: D9:R33.2 85.35,158.32 D9:C33.2 86.44,158.32 87.06,158.94 89.61,158.94 | 89.61,158.94 D9:U1.5 | 89.61,158.94 91.49,158.94 D9:R34.1 D9:C34.1 D9:R51.2
D9:FB+
  Top 0.254: D9:R32.1 D9:R33.1 81.66,158.94 D9:C32.2 D9:R31.2
D9:FB-
  Top 0.254: D9:R43.1 83.03,153.54 | 83.03,153.54 D9:R42.1 | D9:R41.2 D9:C42.2 81.66,153.54 83.03,153.54
D9:N$1  (via drill 0.4)
  Top 0.254: D9:R51.1 D9:R49.1 | D9:R49.1 D9:R45.1 | v94.36,156.08 D9:R49.1
  BOTTOM 0.254: D9:C45.2 D9:R49.1 v94.36,156.08
D9:N$4
  Top 0.254: D9:U1.1 85.96,153.42 D9:C43.1 85.77,153.24 84.84,154.18 D9:R42.2
D9:N$5
  Top 0.254: D9:U1.8 87.5,157.48 87.38,157.35 87.06,157.35 86.74,157.04 86.12,157.04 D9:C33.1 85.04,157.02 D9:R32.2
D9:N$7  (via drill 0.4)
  Top 0.254: D9:R61.1 v94.68,154.18 95.31,154.81 95.31,156.72 D9:R35.2
  BOTTOM 0.254: D9:C35.2 D9:R39.1 92.15,154.5 93.41,154.5 93.73,154.18 v94.68,154.18
D9:N$10
  Top 0.406: D9:R41.1 77.96,152.06 D9:C41.1
D9:R31
  Top 0.406: D9:R31.1 77.96,159.16 D9:C31.1
D9:VB+
  Top 0.406: D9:R37.2 74.04,157.35 74.36,157.04 74.36,156.72 | 74.36,156.72 74.36,156.1 D9:R36.1 | D9:C36.1 74.36,156.72
D9:VB-  (via drill 0.4)
  Top 0.406: D9:C46.1 75.73,154.81 D9:R46.2 74.36,154.8 74.36,153.86 74.04,153.54 D9:R47.1 73.83,153.23 v72.45,153.54
  BOTTOM 0.406: D9:R50.2 72.47,153.56 v72.45,153.54
D9:VCOM  (via drill 0.4)
  Top 0.254: D9:U1.2 88.32,154.16 88.33,154.18 88.33,154.5 88.01,154.81 v86.42,155.13
  BOTTOM 0.254: v86.42,155.13 D9:C7.1 85.18,153.24 D9:R1.2
D10:AMP+
  Top 0.254: 45.13,139.88 41.97,139.89 41.67,140.19 D10:C43.2 40.93,140.19 D10:R43.2 | 45.13,139.88 45.15,140.53 45.15,141.34 D10:U1.4 | 45.13,139.88 45.15,139.89 D10:C44.1 D10:R44.1 D10:R61.2
D10:AMP-
  Top 0.254: D10:R33.2 40.9,146.26 D10:C33.2 41.99,146.26 42.61,146.88 45.16,146.88 | 45.16,146.88 D10:U1.5 | 45.16,146.88 47.04,146.88 D10:R34.1 D10:C34.1 D10:R51.2
D10:FB+
  Top 0.254: D10:R32.1 D10:R33.1 37.21,146.88 D10:C32.2 D10:R31.2
D10:FB-
  Top 0.254: D10:R43.1 38.58,141.48 | 38.58,141.48 D10:R42.1 | D10:R41.2 D10:C42.2 37.21,141.48 38.58,141.48
D10:N$1  (via drill 0.4)
  Top 0.254: D10:R51.1 D10:R49.1 | D10:R49.1 D10:R45.1 | v49.91,144.02 D10:R49.1
  BOTTOM 0.254: D10:C45.2 D10:R49.1 v49.91,144.02
D10:N$4
  Top 0.254: D10:U1.1 41.51,141.35 D10:C43.1 41.32,141.18 40.39,142.11 D10:R42.2
D10:N$5
  Top 0.254: D10:U1.8 43.05,145.41 42.93,145.29 42.61,145.29 42.29,144.97 41.67,144.97 D10:C33.1 40.59,144.96 D10:R32.2
D10:N$7  (via drill 0.4)
  Top 0.254: D10:R61.1 v50.23,142.11 50.86,142.75 50.86,144.65 D10:R35.2
  BOTTOM 0.254: D10:C35.2 D10:R39.1 47.7,142.43 48.96,142.43 49.28,142.11 v50.23,142.11
D10:N$10
  Top 0.406: D10:R41.1 33.51,139.99 D10:C41.1
D10:R31
  Top 0.406: D10:R31.1 33.51,147.09 D10:C31.1
D10:VB+
  Top 0.406: D10:R37.2 29.59,145.29 29.91,144.97 29.91,144.65 | 29.91,144.65 29.91,144.03 D10:R36.1 | D10:C36.1 29.91,144.65
D10:VB-  (via drill 0.4)
  Top 0.406: D10:C46.1 31.28,142.75 D10:R46.2 29.91,142.73 29.91,141.8 29.59,141.48 D10:R47.1 29.38,141.16 v28,141.48
  BOTTOM 0.406: D10:R50.2 28.02,141.49 v28,141.48
D10:VCOM  (via drill 0.4)
  Top 0.254: D10:U1.2 43.87,142.1 43.88,142.11 43.88,142.43 43.56,142.75 v41.97,143.06
  BOTTOM 0.254: v41.97,143.06 D10:C7.1 40.73,141.18 D10:R1.2
D11:AMP+
  Top 0.254: 89.58,139.24 86.42,139.26 86.12,139.56 D11:C43.2 85.38,139.56 D11:R43.2 | 89.58,139.24 89.6,139.89 89.6,140.7 D11:U1.4 | 89.58,139.24 89.6,139.26 D11:C44.1 D11:R44.1 D11:R61.2
D11:AMP-
  Top 0.254: D11:R33.2 85.35,145.62 D11:C33.2 86.44,145.62 87.06,146.24 89.61,146.24 | 89.61,146.24 D11:U1.5 | 89.61,146.24 91.49,146.24 D11:R34.1 D11:C34.1 D11:R51.2
D11:FB+
  Top 0.254: D11:R32.1 D11:R33.1 81.66,146.24 D11:C32.2 D11:R31.2
D11:FB-
  Top 0.254: D11:R43.1 83.03,140.84 | 83.03,140.84 D11:R42.1 | D11:R41.2 D11:C42.2 81.66,140.84 83.03,140.84
D11:N$1  (via drill 0.4)
  Top 0.254: D11:R51.1 D11:R49.1 | D11:R49.1 D11:R45.1 | v94.36,143.38 D11:R49.1
  BOTTOM 0.254: D11:C45.2 D11:R49.1 v94.36,143.38
D11:N$4
  Top 0.254: D11:U1.1 85.96,140.72 D11:C43.1 85.77,140.54 84.84,141.48 D11:R42.2
D11:N$5
  Top 0.254: D11:U1.8 87.5,144.78 87.38,144.65 87.06,144.65 86.74,144.34 86.12,144.34 D11:C33.1 85.04,144.32 D11:R32.2
D11:N$7  (via drill 0.4)
  Top 0.254: D11:R61.1 v94.68,141.48 95.31,142.11 95.31,144.02 D11:R35.2
  BOTTOM 0.254: D11:C35.2 D11:R39.1 92.15,141.8 93.41,141.8 93.73,141.48 v94.68,141.48
D11:N$10
  Top 0.406: D11:R41.1 77.96,139.36 D11:C41.1
D11:R31
  Top 0.406: D11:R31.1 77.96,146.46 D11:C31.1
D11:VB+
  Top 0.406: D11:R37.2 74.04,144.65 74.36,144.34 74.36,144.02 | 74.36,144.02 74.36,143.4 D11:R36.1 | D11:C36.1 74.36,144.02
D11:VB-  (via drill 0.4)
  Top 0.406: D11:C46.1 75.73,142.11 D11:R46.2 74.36,142.1 74.36,141.16 74.04,140.84 D11:R47.1 73.83,140.53 v72.45,140.84
  BOTTOM 0.406: D11:R50.2 72.47,140.86 v72.45,140.84
D11:VCOM  (via drill 0.4)
  Top 0.254: D11:U1.2 88.32,141.47 88.33,141.48 88.33,141.8 88.01,142.11 v86.42,142.43
  BOTTOM 0.254: v86.42,142.43 D11:C7.1 85.18,140.54 D11:R1.2
D12:AMP+
  Top 0.254: 89.58,129.08 86.42,129.09 86.12,129.4 D12:C43.2 85.38,129.4 D12:R43.2 | 89.58,129.08 89.6,129.73 89.6,130.54 D12:U1.4 | 89.58,129.08 89.6,129.09 D12:C44.1 D12:R44.1 D12:R61.2
D12:AMP-
  Top 0.254: D12:R33.2 85.35,135.46 D12:C33.2 86.44,135.46 87.06,136.08 89.61,136.08 | 89.61,136.08 D12:U1.5 | 89.61,136.08 91.49,136.08 D12:R34.1 D12:C34.1 D12:R51.2
D12:FB+
  Top 0.254: D12:R32.1 D12:R33.1 81.66,136.08 D12:C32.2 D12:R31.2
D12:FB-
  Top 0.254: D12:R43.1 83.03,130.68 | 83.03,130.68 D12:R42.1 | D12:R41.2 D12:C42.2 81.66,130.68 83.03,130.68
D12:N$1  (via drill 0.4)
  Top 0.254: D12:R51.1 D12:R49.1 | D12:R49.1 D12:R45.1 | v94.36,133.22 D12:R49.1
  BOTTOM 0.254: D12:C45.2 D12:R49.1 v94.36,133.22
D12:N$4
  Top 0.254: D12:U1.1 85.96,130.56 D12:C43.1 85.77,130.38 84.84,131.32 D12:R42.2
D12:N$5
  Top 0.254: D12:U1.8 87.5,134.62 87.38,134.49 87.06,134.49 86.74,134.18 86.12,134.18 D12:C33.1 85.04,134.16 D12:R32.2
D12:N$7  (via drill 0.4)
  Top 0.254: D12:R61.1 v94.68,131.32 95.31,131.95 95.31,133.86 D12:R35.2
  BOTTOM 0.254: D12:C35.2 D12:R39.1 92.15,131.64 93.41,131.64 93.73,131.32 v94.68,131.32
D12:N$10
  Top 0.406: D12:R41.1 77.96,129.2 D12:C41.1
D12:R31
  Top 0.406: D12:R31.1 77.96,136.3 D12:C31.1
D12:VB+
  Top 0.406: D12:R37.2 74.04,134.49 74.36,134.18 74.36,133.86 | 74.36,133.86 74.36,133.24 D12:R36.1 | D12:C36.1 74.36,133.86
D12:VB-  (via drill 0.4)
  Top 0.406: D12:C46.1 75.73,131.95 D12:R46.2 74.36,131.94 74.36,131 74.04,130.68 D12:R47.1 73.83,130.37 v72.45,130.68
  BOTTOM 0.406: D12:R50.2 72.47,130.7 v72.45,130.68
D12:VCOM  (via drill 0.4)
  Top 0.254: D12:U1.2 88.32,131.31 88.33,131.32 88.33,131.64 88.01,131.95 v86.42,132.27
  BOTTOM 0.254: v86.42,132.27 D12:C7.1 85.18,130.38 D12:R1.2
D13:AMP+
  Top 0.254: 42.59,127.81 39.43,127.83 39.13,128.13 D13:C43.2 38.39,128.13 D13:R43.2 | 42.59,127.81 42.61,128.46 42.61,129.27 D13:U1.4 | 42.59,127.81 42.61,127.83 D13:C44.1 D13:R44.1 D13:R61.2
D13:AMP-
  Top 0.254: D13:R33.2 38.36,134.19 D13:C33.2 39.45,134.19 40.07,134.81 42.62,134.81 | 42.62,134.81 D13:U1.5 | 42.62,134.81 44.5,134.81 D13:R34.1 D13:C34.1 D13:R51.2
D13:FB+
  Top 0.254: D13:R32.1 D13:R33.1 34.67,134.81 D13:C32.2 D13:R31.2
D13:FB-
  Top 0.254: D13:R43.1 36.04,129.41 | 36.04,129.41 D13:R42.1 | D13:R41.2 D13:C42.2 34.67,129.41 36.04,129.41
D13:N$1  (via drill 0.4)
  Top 0.254: D13:R51.1 D13:R49.1 | D13:R49.1 D13:R45.1 | v47.37,131.95 D13:R49.1
  BOTTOM 0.254: D13:C45.2 D13:R49.1 v47.37,131.95
D13:N$4
  Top 0.254: D13:U1.1 38.97,129.29 D13:C43.1 38.78,129.11 37.85,130.05 D13:R42.2
D13:N$5
  Top 0.254: D13:U1.8 40.51,133.35 40.39,133.22 40.07,133.22 39.75,132.91 39.13,132.91 D13:C33.1 38.05,132.89 D13:R32.2
D13:N$7  (via drill 0.4)
  Top 0.254: D13:R61.1 v47.69,130.05 48.32,130.68 48.32,132.59 D13:R35.2
  BOTTOM 0.254: D13:C35.2 D13:R39.1 45.16,130.37 46.42,130.37 46.74,130.05 v47.69,130.05
D13:N$10
  Top 0.406: D13:R41.1 30.97,127.93 D13:C41.1
D13:R31
  Top 0.406: D13:R31.1 30.97,135.03 D13:C31.1
D13:VB+
  Top 0.406: D13:R37.2 27.05,133.22 27.37,132.91 27.37,132.59 | 27.37,132.59 27.37,131.97 D13:R36.1 | D13:C36.1 27.37,132.59
D13:VB-  (via drill 0.4)
  Top 0.406: D13:C46.1 28.74,130.68 D13:R46.2 27.37,130.67 27.37,129.73 27.05,129.41 D13:R47.1 26.84,129.09 v25.46,129.41
  BOTTOM 0.406: D13:R50.2 25.48,129.43 v25.46,129.41
D13:VCOM  (via drill 0.4)
  Top 0.254: D13:U1.2 41.33,130.03 41.34,130.05 41.34,130.37 41.02,130.68 v39.43,131
  BOTTOM 0.254: v39.43,131 D13:C7.1 38.19,129.11 D13:R1.2
D14:AMP+
  Top 0.254: 89.58,113.84 86.42,113.86 86.12,114.16 D14:C43.2 85.38,114.16 D14:R43.2 | 89.58,113.84 89.6,114.49 89.6,115.3 D14:U1.4 | 89.58,113.84 89.6,113.86 D14:C44.1 D14:R44.1 D14:R61.2
D14:AMP-
  Top 0.254: D14:R33.2 85.35,120.22 D14:C33.2 86.44,120.22 87.06,120.84 89.61,120.84 | 89.61,120.84 D14:U1.5 | 89.61,120.84 91.49,120.84 D14:R34.1 D14:C34.1 D14:R51.2
D14:FB+
  Top 0.254: D14:R32.1 D14:R33.1 81.66,120.84 D14:C32.2 D14:R31.2
D14:FB-
  Top 0.254: D14:R43.1 83.03,115.44 | 83.03,115.44 D14:R42.1 | D14:R41.2 D14:C42.2 81.66,115.44 83.03,115.44
D14:N$1  (via drill 0.4)
  Top 0.254: D14:R51.1 D14:R49.1 | D14:R49.1 D14:R45.1 | v94.36,117.98 D14:R49.1
  BOTTOM 0.254: D14:C45.2 D14:R49.1 v94.36,117.98
D14:N$4
  Top 0.254: D14:U1.1 85.96,115.32 D14:C43.1 85.77,115.14 84.84,116.08 D14:R42.2
D14:N$5
  Top 0.254: D14:U1.8 87.5,119.38 87.38,119.25 87.06,119.25 86.74,118.94 86.12,118.94 D14:C33.1 85.04,118.92 D14:R32.2
D14:N$7  (via drill 0.4)
  Top 0.254: D14:R61.1 v94.68,116.08 95.31,116.71 95.31,118.62 D14:R35.2
  BOTTOM 0.254: D14:C35.2 D14:R39.1 92.15,116.39 93.41,116.39 93.73,116.08 v94.68,116.08
D14:N$10
  Top 0.406: D14:R41.1 77.96,113.96 D14:C41.1
D14:R31
  Top 0.406: D14:R31.1 77.96,121.06 D14:C31.1
D14:VB+
  Top 0.406: D14:R37.2 74.04,119.25 74.36,118.94 74.36,118.62 | 74.36,118.62 74.36,118 D14:R36.1 | D14:C36.1 74.36,118.62
D14:VB-  (via drill 0.4)
  Top 0.406: D14:C46.1 75.73,116.71 D14:R46.2 74.36,116.7 74.36,115.76 74.04,115.44 D14:R47.1 73.83,115.13 v72.45,115.44
  BOTTOM 0.406: D14:R50.2 72.47,115.46 v72.45,115.44
D14:VCOM  (via drill 0.4)
  Top 0.254: D14:U1.2 88.32,116.06 88.33,116.08 88.33,116.39 88.01,116.71 v86.42,117.03
  BOTTOM 0.254: v86.42,117.03 D14:C7.1 85.18,115.14 D14:R1.2
D15:AMP+
  Top 0.254: 42.59,115.11 39.43,115.13 39.13,115.43 D15:C43.2 38.39,115.43 D15:R43.2 | 42.59,115.11 42.61,115.76 42.61,116.57 D15:U1.4 | 42.59,115.11 42.61,115.13 D15:C44.1 D15:R44.1 D15:R61.2
D15:AMP-
  Top 0.254: D15:R33.2 38.36,121.49 D15:C33.2 39.45,121.49 40.07,122.11 42.62,122.11 | 42.62,122.11 D15:U1.5 | 42.62,122.11 44.5,122.11 D15:R34.1 D15:C34.1 D15:R51.2
D15:FB+
  Top 0.254: D15:R32.1 D15:R33.1 34.67,122.11 D15:C32.2 D15:R31.2
D15:FB-
  Top 0.254: D15:R43.1 36.04,116.71 | 36.04,116.71 D15:R42.1 | D15:R41.2 D15:C42.2 34.67,116.71 36.04,116.71
D15:N$1  (via drill 0.4)
  Top 0.254: D15:R51.1 D15:R49.1 | D15:R49.1 D15:R45.1 | v47.37,119.25 D15:R49.1
  BOTTOM 0.254: D15:C45.2 D15:R49.1 v47.37,119.25
D15:N$4
  Top 0.254: D15:U1.1 38.97,116.59 D15:C43.1 38.78,116.41 37.85,117.35 D15:R42.2
D15:N$5
  Top 0.254: D15:U1.8 40.51,120.65 40.39,120.52 40.07,120.52 39.75,120.21 39.13,120.21 D15:C33.1 38.05,120.19 D15:R32.2
D15:N$7  (via drill 0.4)
  Top 0.254: D15:R61.1 v47.69,117.35 48.32,117.98 48.32,119.89 D15:R35.2
  BOTTOM 0.254: D15:C35.2 D15:R39.1 45.16,117.67 46.42,117.67 46.74,117.35 v47.69,117.35
D15:N$10
  Top 0.406: D15:R41.1 30.97,115.23 D15:C41.1
D15:R31
  Top 0.406: D15:R31.1 30.97,122.33 D15:C31.1
D15:VB+
  Top 0.406: D15:R37.2 27.05,120.52 27.37,120.21 27.37,119.89 | 27.37,119.89 27.37,119.27 D15:R36.1 | D15:C36.1 27.37,119.89
D15:VB-  (via drill 0.4)
  Top 0.406: D15:C46.1 28.74,117.98 D15:R46.2 27.37,117.97 27.37,117.03 27.05,116.71 D15:R47.1 26.84,116.39 v25.46,116.71
  BOTTOM 0.406: D15:R50.2 25.48,116.73 v25.46,116.71
D15:VCOM  (via drill 0.4)
  Top 0.254: D15:U1.2 41.33,117.33 41.34,117.35 41.34,117.67 41.02,117.98 v39.43,118.3
  BOTTOM 0.254: v39.43,118.3 D15:C7.1 38.19,116.41 D15:R1.2
D16:AMP+
  Top 0.254: 42.59,98.6 39.43,98.61 39.13,98.92 D16:C43.2 38.39,98.92 D16:R43.2 | 42.59,98.6 42.61,99.25 42.61,100.06 D16:U1.4 | 42.59,98.6 42.61,98.61 D16:C44.1 D16:R44.1 D16:R61.2
D16:AMP-
  Top 0.254: D16:R33.2 38.36,104.98 D16:C33.2 39.45,104.98 40.07,105.6 42.62,105.6 | 42.62,105.6 D16:U1.5 | 42.62,105.6 44.5,105.6 D16:R34.1 D16:C34.1 D16:R51.2
D16:FB+
  Top 0.254: D16:R32.1 D16:R33.1 34.67,105.6 D16:C32.2 D16:R31.2
D16:FB-
  Top 0.254: D16:R43.1 36.04,100.2 | 36.04,100.2 D16:R42.1 | D16:R41.2 D16:C42.2 34.67,100.2 36.04,100.2
D16:N$1  (via drill 0.4)
  Top 0.254: D16:R51.1 D16:R49.1 | D16:R49.1 D16:R45.1 | v47.37,102.74 D16:R49.1
  BOTTOM 0.254: D16:C45.2 D16:R49.1 v47.37,102.74
D16:N$4
  Top 0.254: D16:U1.1 38.97,100.08 D16:C43.1 38.78,99.9 37.85,100.84 D16:R42.2
D16:N$5
  Top 0.254: D16:U1.8 40.51,104.14 40.39,104.01 40.07,104.01 39.75,103.69 39.13,103.69 D16:C33.1 38.05,103.68 D16:R32.2
D16:N$7  (via drill 0.4)
  Top 0.254: D16:R61.1 v47.69,100.84 48.32,101.47 48.32,103.38 D16:R35.2
  BOTTOM 0.254: D16:C35.2 D16:R39.1 45.16,101.16 46.42,101.16 46.74,100.84 v47.69,100.84
D16:N$10
  Top 0.406: D16:R41.1 30.97,98.72 D16:C41.1
D16:R31
  Top 0.406: D16:R31.1 30.97,105.82 D16:C31.1
D16:VB+
  Top 0.406: D16:R37.2 27.05,104.01 27.37,103.69 27.37,103.38 | 27.37,103.38 27.37,102.76 D16:R36.1 | D16:C36.1 27.37,103.38
D16:VB-  (via drill 0.4)
  Top 0.406: D16:C46.1 28.74,101.47 D16:R46.2 27.37,101.46 27.37,100.52 27.05,100.2 D16:R47.1 26.84,99.89 v25.46,100.2
  BOTTOM 0.406: D16:R50.2 25.48,100.22 v25.46,100.2
D16:VCOM  (via drill 0.4)
  Top 0.254: D16:U1.2 41.33,100.83 41.34,100.84 41.34,101.16 41.02,101.47 v39.43,101.79
  BOTTOM 0.254: v39.43,101.79 D16:C7.1 38.19,99.9 D16:R1.2
D17:AMP+
  Top 0.254: 78.79,95.68 75.63,95.69 75.33,96 D17:C43.2 74.59,96 D17:R43.2 | 78.79,95.68 78.8,96.33 78.8,97.14 D17:U1.4 | 78.79,95.68 78.8,95.69 D17:C44.1 D17:R44.1 D17:R61.2
D17:AMP-
  Top 0.254: D17:R33.2 74.56,102.06 D17:C33.2 75.64,102.06 76.26,102.68 78.82,102.68 | 78.82,102.68 D17:U1.5 | 78.82,102.68 80.69,102.68 D17:R34.1 D17:C34.1 D17:R51.2
D17:FB+
  Top 0.254: D17:R32.1 D17:R33.1 70.87,102.68 D17:C32.2 D17:R31.2
D17:FB-
  Top 0.254: D17:R43.1 72.24,97.28 | 72.24,97.28 D17:R42.1 | D17:R41.2 D17:C42.2 70.87,97.28 72.24,97.28
D17:N$1  (via drill 0.4)
  Top 0.254: D17:R51.1 D17:R49.1 | D17:R49.1 D17:R45.1 | v83.57,99.82 D17:R49.1
  BOTTOM 0.254: D17:C45.2 D17:R49.1 v83.57,99.82
D17:N$4
  Top 0.254: D17:U1.1 75.17,97.16 D17:C43.1 74.98,96.98 74.04,97.92 D17:R42.2
D17:N$5
  Top 0.254: D17:U1.8 76.71,101.22 76.58,101.09 76.26,101.09 75.95,100.78 75.33,100.78 D17:C33.1 74.24,100.76 D17:R32.2
D17:N$7  (via drill 0.4)
  Top 0.254: D17:R61.1 v83.88,97.92 84.52,98.55 84.52,100.46 D17:R35.2
  BOTTOM 0.254: D17:C35.2 D17:R39.1 81.36,98.23 82.61,98.23 82.93,97.92 v83.88,97.92
D17:N$10
  Top 0.406: D17:R41.1 67.17,95.8 D17:C41.1
D17:R31
  Top 0.406: D17:R31.1 67.17,102.89 D17:C31.1
D17:VB+
  Top 0.406: D17:R37.2 63.25,101.09 63.56,100.78 63.56,100.46 | 63.56,100.46 63.56,99.84 D17:R36.1 | D17:C36.1 63.56,100.46