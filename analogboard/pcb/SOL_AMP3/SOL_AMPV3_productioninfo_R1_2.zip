# EAGLE board SOL_AMPV3 (EAGLE 7.6.0), part 5 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
VTR17  (via drill 0.4, 0.6) (continued)
  Top 0.305: U10.9 65.15,75.44 65.41,75.69 65.41,76.45 64.9,76.96 64.9,77.09 64.64,77.34 64.64,77.85 v64.39,78.11
  Route3 0.305: v64.39,78.11 64.39,79.38 60.58,83.19 60.58,83.82 59.94,84.45 59.94,93.34 v61.59,94.36
  BOTTOM 0.254: D17:R50.1 62.31,95.68 v61.59,94.36
VTR18  (via drill 0.4, 0.6)
  Top 0.305: U9.8 24.38,77.47 25.02,79.38 v25.02,80.01
  Route3 0.305: v25.02,80.01 25.02,85.72 v25.15,86.49
  BOTTOM 0.254: D18:R50.1 26.11,87.42 v25.15,86.49
VTR19  (via drill 0.4, 0.6)
  Top 0.305: U10.8 65.79,74.93 66.29,75.44 v66.29,77.47
  Route3 0.305: v66.29,77.47 66.29,80.01 64.39,81.92 64.39,82.17 v63.88,82.68
  BOTTOM 0.254: D19:R50.1 63.58,83.61 v63.88,82.68
VTR20  (via drill 0.4, 0.6)
  Top 0.305: U9.7 22.35,76.96 22.86,76.71 22.86,75.44 v22.73,75.18
  Route3 0.305: v22.73,75.18 22.73,74.04 v26.42,71.63
  BOTTOM 0.254: D20:R50.1 27.38,71.93 v26.42,71.63
VTR21  (via drill 0.6)
  Top 0.305: U10.7 64.9,74.42 65.66,73.66 v65.66,73.03
  Route3 0.305: v65.66,73.03 65.66,71.12 v68.2,69.22
  BOTTOM 0.305: v68.2,69.22 70.06,69.22 D21:R50.1
VTR22  (via drill 0.4, 0.6)
  Top 0.305: U9.6 21.34,75.44 v21.21,74.3
  Route2 0.305: v21.84,59.69 24.64,59.69 v25.15,60.2
  Route3 0.305: v21.21,74.3 v21.84,59.69
  BOTTOM 0.254: D22:R50.1 26.11,60.5 v25.15,60.2
VTR23  (via drill 0.4, 0.6)
  Top 0.305: U10.6 63.88,72.9 v64.39,72.39
  Route3 0.305: v64.39,72.39 64.39,63.5 v71.5,56.39
  BOTTOM 0.254: D23:R50.1 73.1,57.96 v71.5,56.39
VTR24  (via drill 0.4, 0.6)
  Top 0.254: U11.9 21.72,29.08 v22.48,29.84
  Route3 0.254: v22.48,29.84 22.48,42.29 v25.15,44.96
  BOTTOM 0.254: D24:R50.1 26.11,45.26 v25.15,44.96
VTR25  (via drill 0.4, 0.6)
  Top 0.305: U12.9 66.8,23.37 v68.83,26.04
  Route3 0.305: v68.83,26.04 68.83,39.62 v72.14,42.93
  BOTTOM 0.254: D25:R50.1 73.1,43.23 v72.14,42.93
VTR26  (via drill 0.4, 0.6)
  Top 0.254: U11.8 v25.02,28.57
  Route3 0.254: v25.02,28.57 25.02,33.4 v25.15,33.53
  BOTTOM 0.254: D26:R50.1 26.11,33.83 v25.15,33.53
VTR27  (via drill 0.4, 0.6)
  Top 0.305: U12.8 68.2,22.86 v70.74,25.4
  Route3 0.305: v70.74,25.4 70.74,28.7 v72.52,30.48
  BOTTOM 0.254: D27:R50.1 73.1,31.8 v72.52,30.48
VTR28  (via drill 0.4, 0.6)
  Top 0.254: U11.7 21.72,28.07 v22.48,27.3
  Route3 0.254: v22.48,27.3 22.48,21.59 24.38,19.68 25.65,19.68 v25.78,19.56
  BOTTOM 0.254: D28:R50.1 26.75,20.5 v25.78,19.56
VTR29  (via drill 0.4, 0.6)
  Top 0.305: U12.7 69.34,22.35 v69.47,22.23
  Route3 0.305: v69.47,22.23 69.47,20.19 v71.37,18.29
  BOTTOM 0.254: D29:R50.1 73.1,17.57 v71.37,18.29
VTR30  (via drill 0.4, 0.6)
  Top 0.305: U11.6 20.07,26.54 v20.57,26.04
  Route3 0.305: v20.57,26.04 20.57,12.06 23.75,8.89 25.02,8.89 v25.15,8.76
  BOTTOM 0.254: D30:R50.1 26.75,9.07 v25.15,8.76
VTR31  (via drill 0.4, 0.6)
  Top 0.305: U12.6 65.15,20.45 v65.02,20.32
  Route2 0.305: v65.02,5.08 72.01,5.08 v72.14,4.95
  Route3 0.305: v65.02,20.32 v65.02,5.08
  BOTTOM 0.254: D31:R50.1 73.1,5.89 v72.14,4.95

## Text on the board
Top: component
Route2: layer2
Route3: layer 3
BOTTOM: bottom
tNames: SOL_AMPV3 | REV: | SERIALNR: | Universiteit Antwerpen | Wim Beaumont / (C) 16 October 2016 | Wim Beaumont / (C) 16 October 2016
bNames: SOL_AMPV3 | REV: | Universiteit Antwerpen